# Repository stonedDiscord/ps3 (continued)

## KiCad design cok-001/cok-001.kicad_pcb (continued)

Schematic: bridge.kicad_sch

Parts:
C7347, C7348, C7349, C7350: 0.01u; C_0402_1005Metric
C7354: 100p; C_0402_1005Metric
R7302, R7303, R7304, R7305, R7306, R7307, R7308, R7309: 4700; R_0402_1005Metric
R7311, R7312, R7313, R7318, R7319, R7320: 56; R_0402_1005Metric
R7314: 22; R_0402_1005Metric
RN7301, RN7302, RN7303, RN7304, RN7305, RN7306, RN7307, RN7308, RN7309, RN7310, RN7311, RN7312, RN7313, RN7314, RN7315, RN7316, RN7317, RN7318, RN7319, RN7320, RN7321: 56; R_Array_Convex_4x0402
TP7301, TP7302, TP7303, TP7304, TP7305, TP7306, TP7307, TP7308, TP7309, TP7310, TP7311: TestPoint; TestPoint_Pad_1.0x1.0mm
U7301: CXD9208GP; Xilinx_FTGB196

Connections:
BC_PCI_AD0: R7311.2, U7301.N4 (PCI_AD0)
BC_PCI_AD1: RN7309.5 (R4.2), U7301.M3 (PCI_AD1)
BC_PCI_AD2: RN7304.7 (R2.2), U7301.M2 (PCI_AD2)
BC_PCI_AD3: RN7308.8 (R1.2), U7301.L1 (PCI_AD3)
BC_PCI_AD4: RN7304.6 (R3.2), U7301.M1 (PCI_AD4)
BC_PCI_AD5: RN7309.6 (R3.2), U7301.N2 (PCI_AD5)
BC_PCI_AD6: RN7303.7 (R2.2), U7301.J3 (PCI_AD6)
BC_PCI_AD7: RN7308.7 (R2.2), U7301.L2 (PCI_AD7)
BC_PCI_AD8: RN7309.7 (R2.2), U7301.N1 (PCI_AD8)
BC_PCI_AD9: RN7303.5 (R4.2), U7301.K1 (PCI_AD9)
BC_PCI_AD10: RN7308.6 (R3.2), U7301.K3 (PCI_AD10)
BC_PCI_AD11: RN7303.6 (R3.2), U7301.K2 (PCI_AD11)
BC_PCI_AD12: RN7309.8 (R1.2), U7301.P1 (PCI_AD12)
BC_PCI_AD13: RN7304.8 (R1.2), U7301.L3 (PCI_AD13)
BC_PCI_AD14: RN7308.5 (R4.2), U7301.J1 (PCI_AD14)
BC_PCI_AD15: RN7303.8 (R1.2), U7301.H1 (PCI_AD15)
BC_PCI_AD16: RN7302.5 (R4.2), U7301.H2 (PCI_AD16)
BC_PCI_AD17: RN7307.8 (R1.2), U7301.G3 (PCI_IDSEL), U7301.J2 (PCI_AD17)
BC_PCI_AD18: RN7302.6 (R3.2), U7301.F3 (PCI_AD18)
BC_PCI_AD19: RN7307.7 (R2.2), U7301.H3 (PCI_AD19)
BC_PCI_AD20: RN7302.7 (R2.2), U7301.F1 (PCI_AD20)
BC_PCI_AD21: RN7307.6 (R3.2), U7301.G1 (PCI_AD21)
BC_PCI_AD22: RN7302.8 (R1.2), U7301.F2 (PCI_AD22)
BC_PCI_AD23: RN7307.5 (R4.2), U7301.G2 (PCI_AD23)
BC_PCI_AD24: RN7301.5 (R4.2), U7301.E3 (PCI_AD24)
BC_PCI_AD25: RN7306.8 (R1.2), U7301.E1 (PCI_AD25)
BC_PCI_AD26: RN7301.6 (R3.2), U7301.D1 (PCI_AD26)
BC_PCI_AD27: RN7306.7 (R2.2), U7301.E2 (PCI_AD27)
BC_PCI_AD28: RN7301.7 (R2.2), U7301.D2 (PCI_AD28)
BC_PCI_AD29: RN7306.5 (R4.2), U7301.C2 (PCI_AD29)
BC_PCI_AD30: RN7301.8 (R1.2), U7301.C1 (PCI_AD30)
BC_PCI_AD31: RN7306.6 (R3.2), U7301.D3 (PCI_AD31)
BC_PCI_DEVSEL: R7306.2, RN7310.6 (R3.2), U7301.N6 (~PCI_DEVSEL)
EEGS_HBLK1: U7301.M14 (HBLK)
EEGS_VBLK1: U7301.M13 (VBLK)
GND: C7347.1, C7348.1, C7349.1, C7350.1, C7354.2, U7301.A1 (TEST_IN_0), U7301.A2 (PLLAVS1), U7301.C3 (TEST_IN_1), U7301.C4 (Vss2), U7301.C5 (Vss2), U7301.C11 (Vss), U7301.C12 (Vss), U7301.D4 (Vss), U7301.D7 (Vss), U7301.D10 (Vss), U7301.E4 (Vss2), U7301.E8 (Vss2), U7301.E9 (TEST_IN_3), U7301.E12 (TEST_IN_4), U7301.F6 (Vss), U7301.F7 (Vss), U7301.F8 (TEST_IN_2), U7301.F11 (Vss2), U7301.G4 (Vss), U7301.G5 (Vss2), U7301.G6 (Vss), U7301.G10 (Vss2), U7301.H5 (TEST_PLL_BP_0), U7301.H6 (Vss2), U7301.H10 (Vss), U7301.J6 (Vss), U7301.J8 (Vss), U7301.J9 (Vss), U7301.J10 (Vss2), U7301.K4 (Vss), U7301.K8 (TEST_PLL_BP_1), U7301.K9 (Vss), U7301.K11 (Vss), U7301.L5 (Vss2), U7301.L6 (Vss), U7301.L7 (Vss2), U7301.L8 (Vss), U7301.L11 (Vss), U7301.M4 (Vss2), U7301.P2 (PLLAVS0); also elsewhere on the board
MSCLK: U7301.A3 (SIF_MSCLK)
unnamed: R7302.1, R7303.1, R7304.1, R7305.1, R7306.1, R7307.1, R7308.1, R7309.1
unnamed: R7314.2, RN7304.5 (R4.2)
unnamed: RN7311.8 (R1.2), U7301.N8 (~PCI_GNT)
unnamed: RN7311.7 (R2.2), U7301.P7 (~PCI_CBE3)
unnamed: RN7311.6 (R3.2), U7301.N7 (~PCI_CBE2)
unnamed: RN7311.5 (R4.2), U7301.P4 (~PCI_CBE1)
unnamed: RN7320.1 (R1.1), U7301.A5 (SIF_DACK)
unnamed: RN7320.2 (R2.1), U7301.A6 (SIF_DREQ0)
unnamed: RN7320.3 (R3.1), U7301.A4 (~SIF_WRAC)
unnamed: RN7320.4 (R4.1), U7301.B4 (~SIF_SINT)
unnamed: RN7321.3 (R3.1), U7301.B7 (~SIF_RDY)
unnamed: TP7306.1 (1_1), U7301.F12 (GPIO15_0)
unnamed: TP7311.1 (1_1), U7301.G12 (GPIO15_1)
unnamed: TP7305.1 (1_1), U7301.H12 (GPIO15_2)
unnamed: TP7310.1 (1_1), U7301.J12 (GPIO33_0)
unnamed: TP7304.1 (1_1), U7301.K12 (GPIO33_1)
unnamed: TP7309.1 (1_1), U7301.L12 (GPIO33_2)
unnamed: TP7303.1 (1_1), U7301.M12 (GPIO33_3)
unnamed: TP7308.1 (1_1), U7301.N12 (GPIO33_4)
unnamed: TP7302.1 (1_1), U7301.B2 (GPIO33_5)
unnamed: TP7307.1 (1_1), U7301.B1 (GPIO33_6)
unnamed: TP7301.1 (1_1), U7301.P13 (GPIO33_7)
unnamed: R7312.2, U7301.M6 (PCI_PAR)
unnamed: C7347.2, C7348.2, C7349.2, C7350.2, U7301.B3 (PLLAVD1), U7301.D5 (VddC), U7301.D8 (VddC), U7301.E6 (VddC), U7301.F4 (VddC), U7301.G9 (VddC), U7301.G11 (VddC), U7301.H4 (VddC), U7301.H7 (VddC), U7301.J4 (VddC), U7301.J11 (VddC), U7301.K5 (VddC), U7301.L4 (VddC), U7301.N3 (PLLAVD0)
unnamed: U7301.D6 (Vdd), U7301.D9 (Vdd), U7301.D11 (Vdd), U7301.E7 (Vdd), U7301.E10 (Vdd2), U7301.E11 (Vdd2), U7301.F10 (Vdd), U7301.G8 (Vdd2), U7301.H9 (Vdd2), U7301.H11 (Vdd), U7301.K10 (Vdd)
unnamed: U7301.E5 (VddS), U7301.F5 (VddS), U7301.F9 (VddS), U7301.G7 (VddS), U7301.H8 (VddS), U7301.J5 (VddS), U7301.J7 (VddS), U7301.K6 (VddS), U7301.K7 (VddS), U7301.L9 (VddS), U7301.L10 (VddS)
unnamed: R7313.2, U7301.M8 (~PCI_CBE0)
unnamed: C7354.1, R7314.1, U7301.M10 (~PCI_RST)
PCLKEN: U7301.N13 (PCLKEN); also elsewhere on the board
PWRUP_EE: U7301.P14 (PWRUP_EE); also elsewhere on the board
SB_PCI_AD0: R7311.1; also elsewhere on the board
SB_PCI_AD1: RN7309.4 (R4.1); also elsewhere on the board
SB_PCI_AD2: RN7304.2 (R2.1); also elsewhere on the board
SB_PCI_AD3: RN7308.1 (R1.1); also elsewhere on the board
SB_PCI_AD4: RN7304.3 (R3.1); also elsewhere on the board
SB_PCI_AD5: RN7309.3 (R3.1); also elsewhere on the board
SB_PCI_AD6: RN7303.2 (R2.1); also elsewhere on the board
SB_PCI_AD7: RN7308.2 (R2.1); also elsewhere on the board
SB_PCI_AD8: RN7309.2 (R2.1); also elsewhere on the board
SB_PCI_AD9: RN7303.4 (R4.1); also elsewhere on the board
SB_PCI_AD10: RN7308.3 (R3.1); also elsewhere on the board
SB_PCI_AD11: RN7303.3 (R3.1); also elsewhere on the board
SB_PCI_AD12: RN7309.1 (R1.1); also elsewhere on the board
SB_PCI_AD13: RN7304.1 (R1.1); also elsewhere on the board
SB_PCI_AD14: RN7308.4 (R4.1); also elsewhere on the board
SB_PCI_AD15: RN7303.1 (R1.1); also elsewhere on the board
SB_PCI_AD16: RN7302.4 (R4.1); also elsewhere on the board
SB_PCI_AD17: RN7307.1 (R1.1); also elsewhere on the board
SB_PCI_AD18: RN7302.3 (R3.1); also elsewhere on the board
SB_PCI_AD19: RN7307.2 (R2.1); also elsewhere on the board
SB_PCI_AD20: RN7302.2 (R2.1); also elsewhere on the board
SB_PCI_AD21: RN7307.3 (R3.1); also elsewhere on the board
SB_PCI_AD22: RN7302.1 (R1.1); also elsewhere on the board
SB_PCI_AD23: RN7307.4 (R4.1); also elsewhere on the board
SB_PCI_AD24: RN7301.4 (R4.1); also elsewhere on the board
SB_PCI_AD25: RN7306.1 (R1.1); also elsewhere on the board
SB_PCI_AD26: RN7301.3 (R3.1); also elsewhere on the board
SB_PCI_AD27: RN7306.2 (R2.1); also elsewhere on the board
SB_PCI_AD28: RN7301.2 (R2.1); also elsewhere on the board
SB_PCI_AD29: RN7306.4 (R4.1); also elsewhere on the board
SB_PCI_AD30: RN7301.1 (R1.1); also elsewhere on the board
SB_PCI_AD31: RN7306.3 (R3.1); also elsewhere on the board
SB_PCI_PAR: R7312.1; also elsewhere on the board
SIF_AD0: RN7312.7 (R2.2); also elsewhere on the board
SIF_AD1: RN7312.6 (R3.2); also elsewhere on the board
SIF_AD2: RN7312.5 (R4.2); also elsewhere on the board
SIF_AD3: RN7312.8 (R1.2); also elsewhere on the board
SIF_AD4: RN7313.8 (R1.2); also elsewhere on the board
SIF_AD5: RN7317.5 (R4.2); also elsewhere on the board
SIF_AD6: RN7313.5 (R4.2); also elsewhere on the board
SIF_AD7: RN7313.7 (R2.2); also elsewhere on the board
SIF_AD8: RN7317.7 (R2.2); also elsewhere on the board
SIF_AD9: RN7313.6 (R3.2); also elsewhere on the board
SIF_AD10: RN7317.6 (R3.2); also elsewhere on the board
SIF_AD11: RN7316.8 (R1.2); also elsewhere on the board
SIF_AD12: RN7317.8 (R1.2); also elsewhere on the board
SIF_AD13: RN7316.5 (R4.2); also elsewhere on the board
SIF_AD14: RN7316.6 (R3.2); also elsewhere on the board
SIF_AD15: RN7316.7 (R2.2); also elsewhere on the board
SIF_AD16: RN7314.5 (R4.2); also elsewhere on the board
SIF_AD17: RN7314.8 (R1.2); also elsewhere on the board
SIF_AD18: RN7315.6 (R3.2); also elsewhere on the board
SIF_AD19: RN7314.7 (R2.2); also elsewhere on the board
SIF_AD20: RN7315.7 (R2.2); also elsewhere on the board
SIF_AD21: RN7315.8 (R1.2); also elsewhere on the board
SIF_AD22: RN7314.6 (R3.2); also elsewhere on the board
SIF_AD23: RN7318.7 (R2.2); also elsewhere on the board
SIF_AD24: RN7318.8 (R1.2); also elsewhere on the board
SIF_AD25: RN7318.6 (R3.2); also elsewhere on the board
SIF_AD26: RN7319.7 (R2.2); also elsewhere on the board
SIF_AD27: RN7318.5 (R4.2); also elsewhere on the board
SIF_AD28: RN7315.5 (R4.2); also elsewhere on the board
SIF_AD29: RN7319.6 (R3.2); also elsewhere on the board
SIF_AD30: RN7319.5 (R4.2); also elsewhere on the board
SIF_AD31: RN7319.8 (R1.2); also elsewhere on the board
SIF_BC_AD0: RN7312.2 (R2.1), U7301.C9 (SIF_AD0)
SIF_BC_AD1: RN7312.3 (R3.1), U7301.B9 (SIF_AD1)
SIF_BC_AD2: RN7312.4 (R4.1), U7301.C8 (SIF_AD2)
SIF_BC_AD3: RN7312.1 (R1.1), U7301.B10 (SIF_AD3)
SIF_BC_AD4: RN7313.1 (R1.1), U7301.A8 (SIF_AD4)
SIF_BC_AD5: RN7317.4 (R4.1), U7301.D13 (SIF_AD5)
SIF_BC_AD6: RN7313.4 (R4.1), U7301.A14 (SIF_AD6)
SIF_BC_AD7: RN7313.2 (R2.1), U7301.A9 (SIF_AD7)
SIF_BC_AD8: RN7317.2 (R2.1), U7301.E13 (SIF_AD8)
SIF_BC_AD9: RN7313.3 (R3.1), U7301.A10 (SIF_AD9)
SIF_BC_AD10: RN7317.3 (R3.1), U7301.D12 (SIF_AD10)
SIF_BC_AD11: RN7316.1 (R1.1), U7301.B14 (SIF_AD11)
SIF_BC_AD12: RN7317.1 (R1.1), U7301.F13 (SIF_AD12)
SIF_BC_AD13: RN7316.4 (R4.1), U7301.E14 (SIF_AD13)
SIF_BC_AD14: RN7316.3 (R3.1), U7301.D14 (SIF_AD14)
SIF_BC_AD15: RN7316.2 (R2.1), U7301.C14 (SIF_AD15)
SIF_BC_AD16: RN7314.4 (R4.1), U7301.G13 (SIF_AD16)
SIF_BC_AD17: RN7314.1 (R1.1), U7301.K13 (SIF_AD17)
SIF_BC_AD18: RN7315.3 (R3.1), U7301.A11 (SIF_AD18)
SIF_BC_AD19: RN7314.2 (R2.1), U7301.J13 (SIF_AD19)
SIF_BC_AD20: RN7315.2 (R2.1), U7301.B11 (SIF_AD20)
SIF_BC_AD21: RN7315.1 (R1.1), U7301.A12 (SIF_AD21)
SIF_BC_AD22: RN7314.3 (R3.1), U7301.H13 (SIF_AD22)
SIF_BC_AD23: RN7318.2 (R2.1), U7301.G14 (SIF_AD23)
SIF_BC_AD24: RN7318.1 (R1.1), U7301.F14 (SIF_AD24)
SIF_BC_AD25: RN7318.3 (R3.1), U7301.H14 (SIF_AD25)
SIF_BC_AD26: RN7319.2 (R2.1), U7301.B13 (SIF_AD26)
SIF_BC_AD27: RN7318.4 (R4.1), U7301.J14 (SIF_AD27)
SIF_BC_AD28: RN7315.4 (R4.1), U7301.C10 (SIF_AD28)
SIF_BC_AD29: RN7319.3 (R3.1), U7301.A13 (SIF_AD29)
SIF_BC_AD30: RN7319.4 (R4.1), U7301.B12 (SIF_AD30)
SIF_BC_AD31: RN7319.1 (R1.1), U7301.C13 (SIF_AD31)
SIF_DACK: RN7320.8 (R1.2); also elsewhere on the board
SIF_DREQ0: RN7320.7 (R2.2); also elsewhere on the board
SW1.2: U7301.P11 (SW1.2)
SW1.5: U7301.M11 (SW1.5)
SW1.8: U7301.P9 (SW1.8)
SW1.81: U7301.N11 (SW1.81)
SW2.5: U7301.P10 (SW2.5); also elsewhere on the board
SW2.65: U7301.N9 (SW2.65)
SW3.1: U7301.P12 (SW3.1); also elsewhere on the board
SW3.3: U7301.N10 (SW3.3); also elsewhere on the board
~BC_PCI_FRAME: R7302.2, RN7305.8 (R1.2), U7301.M9 (~PCI_FRAME)
~BC_PCI_IRDY: R7304.2, RN7310.7 (R2.2), U7301.P6 (~PCI_IRDY)
~BC_PCI_PERR: R7307.2, RN7310.5 (R4.2), U7301.P5 (~PCI_PERR)
~BC_PCI_REQ1: R7309.2, RN7310.8 (R1.2), U7301.P8 (~PCI_REQ)
~BC_PCI_SERR: R7308.2, RN7305.5 (R4.2), U7301.N5 (~PCI_SERR)
~BC_PCI_STOP: R7305.2, RN7305.7 (R2.2), U7301.M5 (~PCI_STOP)
~BC_PCI_TRDY: R7303.2, RN7305.6 (R3.2), U7301.M7 (~PCI_TRDY)
~BGNT_BC: R7320.2, U7301.L13 (~SIF_BGNT)
~BGNT: R7320.1
~BREQ_BC: R7319.2, U7301.K14 (~SIF_BREQ)
~BREQ: R7319.1
~EGRST: U7301.N14 (~EGRST); also elsewhere on the board
~SB_PCI_CBE0: R7313.1; also elsewhere on the board
~SB_PCI_CBE1: RN7311.4 (R4.1); also elsewhere on the board
~SB_PCI_CBE2: RN7311.3 (R3.1); also elsewhere on the board
~SB_PCI_CBE3: RN7311.2 (R2.1); also elsewhere on the board
~SB_PCI_DEVSEL: RN7310.3 (R3.1); also elsewhere on the board
~SB_PCI_FRAME: RN7305.1 (R1.1); also elsewhere on the board
~SB_PCI_GNT1: RN7311.1 (R1.1); also elsewhere on the board
~SB_PCI_IRDY: RN7310.2 (R2.1); also elsewhere on the board
~SB_PCI_PERR: RN7310.4 (R4.1); also elsewhere on the board
~SB_PCI_REQ1: RN7310.1 (R1.1)
~SB_PCI_SERR: RN7305.4 (R4.1); also elsewhere on the board
~SB_PCI_STOP: RN7305.2 (R2.1); also elsewhere on the board
~SB_PCI_TRDY: RN7305.3 (R3.1); also elsewhere on the board
~SIF_BE0_BC: RN7321.4 (R4.1), U7301.C6 (~SIF_BE0)
~SIF_BE0: RN7321.5 (R4.2)
~SIF_BE1_BC: RN7321.2 (R2.1), U7301.C7 (~SIF_BE1)
~SIF_BE1: RN7321.7 (R2.2)
~SIF_BE2_BC: RN7321.1 (R1.1), U7301.B8 (~SIF_BE2)
~SIF_BE2: RN7321.8 (R1.2)
~SIF_BE3_BC: R7318.2, U7301.B5 (~SIF_BE3)
~SIF_BE3: R7318.1
~SIF_RDY: RN7321.6 (R3.2)
~SIF_WRAC: RN7320.6 (R3.2); also elsewhere on the board
~SINT: RN7320.5 (R4.2); also elsewhere on the board

Schematic: gpu.kicad_sch

Parts:
R2061: 240; R_0402_1005Metric
R2063, R2064, R2065: 22; R_0402_1005Metric
R2067: 60.4; R_0402_1005Metric
R2068, R2070: 39.2; R_0402_1005Metric
R2071: 240; R_0603_1608Metric
U2001: RSX

Connections:
+1.2V_RSX_VDDR: U2001.E3 (VDDR), U2001.E4 (VDDR), U2001.E5 (VDDR), U2001.F4 (VDDR), U2001.G3 (VDDR), U2001.G4 (VDDR), U2001.G5 (VDDR), U2001.G6 (VDDR), U2001.G7 (VDDR), U2001.G8 (VDDR), U2001.M12 (VDDR), U2001.N10 (VDDR), U2001.P12 (VDDR), U2001.V12 (VDDR)
+1.2V_YC_RC_VDDIO: U2001.AL8 (VDDIORW), U2001.AL10 (VDDIORW), U2001.J5 (VDDIORW), U2001.L10 (VDDIORW), U2001.N5 (VDDIORW), U2001.N8 (VDDIORW), U2001.R10 (VDDIORW), U2001.V5 (VDDIORW), U2001.V8 (VDDIORW); also elsewhere on the board
+1.8V_RSX_FBVDDQ: U2001.J34 (FBVDD), U2001.J36 (FBVDD), U2001.J37 (FBVDD)
BE_RX0_RXCLKN: U2001.P3 (TX0_TXCKN); also elsewhere on the board
BE_RX0_RXCLKP: U2001.P4 (TX0_TXCKP); also elsewhere on the board
BE_RX0_RXN0: U2001.R3 (TX0_TXN0); also elsewhere on the board
BE_RX0_RXN1: U2001.R6 (TX0_TXN1); also elsewhere on the board
BE_RX0_RXN2: U2001.R1 (TX0_TXN2); also elsewhere on the board
BE_RX0_RXN3: U2001.P6 (TX0_TXN3); also elsewhere on the board
BE_RX0_RXN4: U2001.N3 (TX2_TXN4); also elsewhere on the board
BE_RX0_RXN5: U2001.N6 (TX5_TXN5); also elsewhere on the board
BE_RX0_RXN6: U2001.N1 (TX0_TXN6); also elsewhere on the board
BE_RX0_RXN7: U2001.M6 (TX0_TXN7); also elsewhere on the board
BE_RX0_RXP0: U2001.R4 (TX0_TXP0); also elsewhere on the board
BE_RX0_RXP1: U2001.R7 (TX0_TXP1); also elsewhere on the board
BE_RX0_RXP2: U2001.R2 (TX0_TXP2); also elsewhere on the board
BE_RX0_RXP3: U2001.P7 (TX0_TXP3); also elsewhere on the board
BE_RX0_RXP4: U2001.N4 (TX3_TXP4); also elsewhere on the board
BE_RX0_RXP5: U2001.N7 (TX6_TXP5); also elsewhere on the board
BE_RX0_RXP6: U2001.N2 (TX1_TXP6); also elsewhere on the board
BE_RX0_RXP7: U2001.M7 (TX0_TXP7); also elsewhere on the board
BE_RX1_RXCLKN: U2001.AA3 (TX1_TXCKN); also elsewhere on the board
BE_RX1_RXCLKP: U2001.AA4 (TX1_TXCKP); also elsewhere on the board
BE_RX1_RXN0: U2001.AB3 (TX1_TXN0); also elsewhere on the board
BE_RX1_RXN1: U2001.AB6 (TX1_TXN1); also elsewhere on the board
BE_RX1_RXN2: U2001.AB1 (TX1_TXN2); also elsewhere on the board
BE_RX1_RXN3: U2001.AA6 (TX1_TXN3); also elsewhere on the board
BE_RX1_RXN4: U2001.Y3 (TX1_TXN4); also elsewhere on the board
BE_RX1_RXN5: U2001.Y6 (TX1_TXN5); also elsewhere on the board
BE_RX1_RXN6: U2001.Y1 (TX1_TXN6); also elsewhere on the board
BE_RX1_RXN7: U2001.W6 (TX1_TXN7); also elsewhere on the board
BE_RX1_RXP0: U2001.AB4 (TX1_TXP0); also elsewhere on the board
BE_RX1_RXP1: U2001.AB7 (TX1_TXP1); also elsewhere on the board
BE_RX1_RXP2: U2001.AB2 (TX1_TXP2); also elsewhere on the board
BE_RX1_RXP3: U2001.AA7 (TX1_TXP3); also elsewhere on the board
BE_RX1_RXP4: U2001.Y4 (TX1_TXP4); also elsewhere on the board
BE_RX1_RXP5: U2001.Y7 (TX1_TXP5); also elsewhere on the board
BE_RX1_RXP6: U2001.Y2 (TX1_TXP6); also elsewhere on the board
BE_RX1_RXP7: U2001.W7 (TX1_TXP7); also elsewhere on the board
BE_RX2_RXCLKN: U2001.AH3 (TX2_TXCKN); also elsewhere on the board
BE_RX2_RXCLKP: U2001.AH4 (TX2_TXCKP); also elsewhere on the board
BE_RX2_RXN0: U2001.AJ3 (TX2_TXN0); also elsewhere on the board
BE_RX2_RXN2: U2001.AJ1 (TX2_TXN2); also elsewhere on the board
BE_RX2_RXN3: U2001.AH6 (TX2_TXN3); also elsewhere on the board
BE_RX2_RXN4: U2001.AG3 (TX2_TXN4); also elsewhere on the board
BE_RX2_RXN5: U2001.AG6 (TX2_TXN5); also elsewhere on the board
BE_RX2_RXN6: U2001.AG1 (TX2_TXN6); also elsewhere on the board
BE_RX2_RXN7: U2001.AF6 (TX2_TXN7); also elsewhere on the board
BE_RX2_RXP0: U2001.AJ4 (TX2_TXP0); also elsewhere on the board
BE_RX2_RXP2: U2001.AJ2 (TX2_TXP2); also elsewhere on the board
BE_RX2_RXP3: U2001.AH7 (TX2_TXP3); also elsewhere on the board
BE_RX2_RXP4: U2001.AG4 (TX2_TXP4); also elsewhere on the board
BE_RX2_RXP5: U2001.AG7 (TX2_TXP5); also elsewhere on the board
BE_RX2_RXP6: U2001.AG2 (TX2_TXP6); also elsewhere on the board
BE_RX2_RXP7: U2001.AF7 (TX2_TXP7); also elsewhere on the board
BE_TX0_TXCLKN: U2001.K4 (RX0_RXCKN); also elsewhere on the board
BE_TX0_TXCLKP: U2001.K3 (RX0_RXCKP); also elsewhere on the board
BE_TX0_TXN0: U2001.J2 (RX0_RXN0); also elsewhere on the board
BE_TX0_TXN1: U2001.J7 (RX0_RXN1); also elsewhere on the board
BE_TX0_TXN2: U2001.J4 (RX0_RXN2); also elsewhere on the board
BE_TX0_TXN3: U2001.K7 (RX0_RXN3); also elsewhere on the board
BE_TX0_TXN4: U2001.L2 (RX0_RXN4); also elsewhere on the board
BE_TX0_TXN5: U2001.L7 (RX0_RXN5); also elsewhere on the board
BE_TX0_TXN6: U2001.L4 (RX0_RXN6); also elsewhere on the board
BE_TX0_TXN7: U2001.M4 (RX0_RXN7); also elsewhere on the board
BE_TX0_TXP0: U2001.J1 (RX0_RXP0); also elsewhere on the board
BE_TX0_TXP1: U2001.J6 (RX0_RXP1); also elsewhere on the board
BE_TX0_TXP2: U2001.J3 (RX0_RXP2); also elsewhere on the board
BE_TX0_TXP3: U2001.K6 (RX0_RXP3); also elsewhere on the board
BE_TX0_TXP4: U2001.L1 (RX0_RXP4); also elsewhere on the board
BE_TX0_TXP5: U2001.L6 (RX0_RXP5); also elsewhere on the board
BE_TX0_TXP6: U2001.L3 (RX0_RXP6); also elsewhere on the board
BE_TX0_TXP7: U2001.M3 (RX0_RXP7); also elsewhere on the board
BE_TX1_TXCLKN: U2001.U4 (RX1_RXCLN); also elsewhere on the board
BE_TX1_TXCLKP: U2001.U3 (RX1_RXCKP); also elsewhere on the board
BE_TX1_TXN0: U2001.T2 (RX1_RXN0); also elsewhere on the board
BE_TX1_TXN1: U2001.T7 (RX1_RXN1); also elsewhere on the board
BE_TX1_TXN2: U2001.T4 (RX1_RXN2); also elsewhere on the board
BE_TX1_TXN3: U2001.U7 (RX1_RXN3); also elsewhere on the board
BE_TX1_TXN4: U2001.V2 (RX1_RXN4); also elsewhere on the board
BE_TX1_TXN5: U2001.V7 (RX1_RXN5); also elsewhere on the board
BE_TX1_TXN6: U2001.V4 (RX1_RXN6); also elsewhere on the board
BE_TX1_TXN7: U2001.W4 (RX1_RXN7); also elsewhere on the board
BE_TX1_TXP0: U2001.T1 (RX1_RXP0); also elsewhere on the board
BE_TX1_TXP1: U2001.T6 (RX1_RXP1); also elsewhere on the board
BE_TX1_TXP2: U2001.T3 (RX1_RXP2); also elsewhere on the board
BE_TX1_TXP3: U2001.U6 (RX1_RXP3); also elsewhere on the board
BE_TX1_TXP4: U2001.V1 (RX1_RXP4); also elsewhere on the board
BE_TX1_TXP5: U2001.V6 (RX1_RXP5); also elsewhere on the board
BE_TX1_TXP6: U2001.V3 (RX1_RXP6); also elsewhere on the board
BE_TX1_TXP7: U2001.W3 (RX1_RXP7); also elsewhere on the board
BE_TX2_TXCLKN: U2001.AD4 (RX2_RXCKN); also elsewhere on the board
BE_TX2_TXCLKP: U2001.AD3 (RX2_RXCKP); also elsewhere on the board
BE_TX2_TXN0: U2001.AC2 (RX2_RXN0); also elsewhere on the board
BE_TX2_TXN1: U2001.AC7 (RX2_RXN1); also elsewhere on the board
BE_TX2_TXN2: U2001.AC4 (RX2_RXN2); also elsewhere on the board
BE_TX2_TXN3: U2001.AD7 (RX2_RXN3); also elsewhere on the board
BE_TX2_TXN4: U2001.AE2 (RX2_RXN4); also elsewhere on the board
BE_TX2_TXN5: U2001.AE7 (RX2_RXN5); also elsewhere on the board
BE_TX2_TXN6: U2001.AE4 (RX2_RXN6); also elsewhere on the board
BE_TX2_TXN7: U2001.AF4 (RX2_RXN7); also elsewhere on the board
BE_TX2_TXP0: U2001.AC1 (RX2_RXP0); also elsewhere on the board
BE_TX2_TXP1: U2001.AC6 (RX2_RXP1); also elsewhere on the board
BE_TX2_TXP2: U2001.AC3 (RX2_RXP2); also elsewhere on the board
BE_TX2_TXP3: U2001.AD6 (RX2_RXP3); also elsewhere on the board
BE_TX2_TXP4: U2001.AE1 (RX2_RXP4); also elsewhere on the board
BE_TX2_TXP5: U2001.AE6 (RX2_RXP5); also elsewhere on the board
BE_TX2_TXP6: U2001.AE3 (RX2_RXP6); also elsewhere on the board
BE_TX2_TXP7: U2001.AF3 (RX2_RXP7); also elsewhere on the board
BE_TX3_TXCLKN: U2001.AL4 (RX3_RXCKN); also elsewhere on the board
BE_TX3_TXCLKP: U2001.AL3 (RX3_RXCKP); also elsewhere on the board
BE_TX3_TXN0: U2001.AK2 (RX3_RXN0); also elsewhere on the board
BE_TX3_TXN1: U2001.AK7 (RX3_RXN1); also elsewhere on the board
BE_TX3_TXN2: U2001.AK4 (RX3_RXN2); also elsewhere on the board
BE_TX3_TXN3: U2001.AL7 (RX3_RXN3)
BE_TX3_TXN4: U2001.AM2 (RX3_RXN4); also elsewhere on the board
BE_TX3_TXN5: U2001.AM7 (RX3_RXN5); also elsewhere on the board
BE_TX3_TXN6: U2001.AM4 (RX3_RXN6); also elsewhere on the board
BE_TX3_TXN7: U2001.AN4 (RX_RXN7); also elsewhere on the board
BE_TX3_TXP0: U2001.AK1 (RX3_RXP0); also elsewhere on the board
BE_TX3_TXP1: U2001.AK6 (RX3_RXP1); also elsewhere on the board
BE_TX3_TXP2: U2001.AK3 (RX3_RXP2); also elsewhere on the board
BE_TX3_TXP3: U2001.AL6 (RX3_RXP3)
BE_TX3_TXP4: U2001.AM1 (RX3_RXP4); also elsewhere on the board
BE_TX3_TXP5: U2001.AM6 (RX3_RXP5); also elsewhere on the board
BE_TX3_TXP6: U2001.AM3 (RX3_RXP6); also elsewhere on the board
BE_TX3_TXP7: U2001.AN3 (RX_RXP7); also elsewhere on the board
GND: R2061.2, R2068.1, R2070.1, R2071.2, U2001.A6 (GND), U2001.A8 (GND), U2001.A10 (GND), U2001.A12 (GND), U2001.A14 (GND), U2001.A16 (GND), U2001.A18 (GND), U2001.A20 (GND), U2001.A22 (GND), U2001.A24 (GND), U2001.A26 (GND), U2001.A28 (GND), U2001.A30 (GND), U2001.A39 (GND), U2001.AE8 (GND), U2001.AE12 (GND), U2001.AE14 (GND), U2001.AE28 (GND), U2001.AE35 (GND), U2001.AE38 (GND), U2001.AF8 (GND), U2001.AF10 (GND), U2001.AF15 (GND), U2001.AF27 (GND), U2001.AF30 (GND), U2001.AF32 (GND), U2001.AF34 (GND), U2001.AF37 (GND), U2001.AL5 (GND), U2001.AL35 (GND), U2001.AL41 (GND), U2001.AP12 (GND), U2001.AP14 (GND), U2001.AP16 (GND), U2001.AP18 (GND), U2001.AP20 (GND), U2001.AP22 (GND), U2001.AP24 (GND), U2001.AP26 (GND), U2001.AP28 (GND), U2001.AP30 (GND), U2001.AP32 (GND), U2001.AR13 (GND), U2001.AR15 (GND), U2001.AR17 (GND), U2001.AR19 (GND), U2001.AR21 (GND), U2001.AR23 (GND), U2001.AR25 (GND), U2001.AR27 (GND), U2001.AR29 (GND), U2001.AR31 (GND), U2001.AR33 (GND), U2001.AR35 (GND), U2001.B5 (GND), U2001.B7 (GND), U2001.B9 (GND), U2001.B11 (GND), U2001.B13 (GND), U2001.B15 (GND), U2001.B17 (GND), U2001.B19 (GND), U2001.B21 (GND), U2001.B23 (GND), U2001.B25 (GND), U2001.B27 (GND), U2001.B29 (GND), U2001.C6 (GND), U2001.C8 (GND), U2001.C10 (GND), U2001.C12 (GND), U2001.C14 (GND), U2001.C16 (GND), U2001.C18 (GND), U2001.C20 (GND), U2001.C22 (GND), U2001.C24 (GND), U2001.C26 (GND), U2001.C28 (GND), U2001.C30 (GND), U2001.D3 (GND), U2001.D5 (GND), U2001.D7 (GND), U2001.D9 (GND), U2001.D11 (GND), U2001.D13 (GND), U2001.D15 (GND), U2001.D17 (GND), U2001.D19 (GND), U2001.D21 (GND), U2001.D23 (GND), U2001.D25 (GND), U2001.D27 (GND), U2001.D29 (GND), U2001.D31 (GND), U2001.D33 (GND), U2001.E6 (GND), U2001.E8 (GND), U2001.E10 (GND), U2001.E12 (GND), U2001.E14 (GND), U2001.E16 (GND), U2001.E18 (GND), U2001.E20 (GND), U2001.E22 (GND), U2001.E24 (GND), U2001.E26 (GND), U2001.E28 (GND), U2001.E30 (GND), U2001.F3 (GND), U2001.F5 (GND), U2001.F7 (GND), U2001.F9 (GND), U2001.F11 (GND), U2001.F13 (GND), U2001.F15 (GND), U2001.F17 (GND), U2001.F19 (GND), U2001.F21 (GND), U2001.F23 (GND), U2001.F25 (GND), U2001.F27 (GND), U2001.F29 (GND), U2001.F31 (GND), U2001.F33 (GND), U2001.F34 (GND), U2001.F37 (GND), U2001.G2 (FB_SEN2), U2001.G10 (GND), U2001.G12 (GND), U2001.G14 (GND), U2001.G16 (GND), U2001.G18 (GND), U2001.G20 (GND), U2001.G22 (GND), U2001.G24 (GND), U2001.G26 (GND), U2001.G28 (GND), U2001.G30 (GND), U2001.G32 (GND), U2001.G35 (GND), U2001.G41 (GND), U2001.H3 (GND), U2001.H4 (GND), U2001.H5 (GND), U2001.H6 (GND), U2001.H7 (GND), U2001.H9 (GND), U2001.H11 (GND), U2001.H13 (GND), U2001.H15 (GND), U2001.H17 (GND), U2001.H19 (GND), U2001.H21 (GND), U2001.H23 (GND), U2001.H25 (GND), U2001.H27 (GND), U2001.H29 (GND), U2001.H31 (GND), U2001.H34 (GND), U2001.H36 (GND), U2001.H37 (GND), U2001.J8 (GND), U2001.J35 (GND), U2001.J38 (GND), U2001.K14 (GND), U2001.K16 (GND), U2001.K18 (GND), U2001.K20 (GND), U2001.K22 (GND), U2001.K24 (GND), U2001.K26 (GND), U2001.K28 (GND), U2001.K34 (GND), U2001.K37 (FB_MF1), U2001.K38 (FB_SEN1), U2001.L5 (GND), U2001.L8 (GND), U2001.L35 (GND), U2001.L39 (GND), U2001.M5 (GND), U2001.M8 (GND), U2001.M10 (GND), U2001.M15 (GND), U2001.M17 (GND), U2001.M19 (GND), U2001.M21 (GND), U2001.M23 (GND), U2001.M25 (GND), U2001.M27 (GND), U2001.M30 (GND), U2001.M32 (GND), U2001.M34 (GND), U2001.M36 (GND), U2001.N12 (GND), U2001.N35 (GND), U2001.N38 (GND), U2001.P10 (GND), U2001.P15 (GND), U2001.P17 (GND), U2001.P19 (GND), U2001.P21 (GND), U2001.P23 (GND), U2001.P25 (GND), U2001.P27 (GND), U2001.P30 (GND), U2001.P34 (GND), U2001.P37 (GND), U2001.R5 (GND), U2001.R8 (GND), U2001.R12 (GND), U2001.R14 (GND), U2001.R16 (GND), U2001.R18 (GND), U2001.R20 (GND), U2001.R22 (GND), U2001.R24 (GND), U2001.R26 (GND), U2001.R28 (GND), U2001.R35 (GND), U2001.R41 (GND), U2001.V10 (GND), U2001.V15 (GND), U2001.V19 (GND), U2001.V21 (GND), U2001.V23 (GND), U2001.V27 (GND), U2001.V30 (GND), U2001.V34 (GND), U2001.V37 (GND), U2001.W18 (GND), U2001.W20 (GND), U2001.W22 (GND), U2001.W24 (GND), U2001.W28 (GND), U2001.Y15 (GND), U2001.Y19 (GND), U2001.Y21 (GND), U2001.Y23 (GND), U2001.Y27 (GND); also elsewhere on the board
unnamed: R2067.1, U2001.H32 (FBVDD), U2001.H33 (FBVDD), U2001.H35 (FBVDD), U2001.H38 (FBVDD), U2001.H39 (FBVDD)
unnamed: U2001.A34 (FBVDD), U2001.A35 (FBVDD), U2001.A36 (FBVDD), U2001.A37 (FBVDD), U2001.A38 (FBVDD)
unnamed: U2001.A7 (VDD), U2001.A9 (VDD), U2001.A11 (VDD), U2001.A13 (VDD), U2001.A15 (VDD), U2001.A17 (VDD), U2001.A19 (VDD), U2001.A21 (VDD), U2001.A23 (VDD), U2001.A25 (VDD), U2001.A27 (VDD), U2001.A29 (VDD)
unnamed: U2001.A3 (VDDR), U2001.A4 (VDDR), U2001.A5 (VDDR)
unnamed: R2064.2, U2001.AY19 (BCLKO)
unnamed: R2063.2, U2001.AY18 (LRCKO)
unnamed: R2065.2, U2001.AY20 (SDOUT1)
unnamed: U2001.B34 (FBVDD), U2001.B35 (FBVDD), U2001.B36 (FBVDD), U2001.B37 (FBVDD), U2001.B38 (FBVDD), U2001.B39 (FBVDD), U2001.B40 (FBVDD)
unnamed: U2001.B6 (VDD), U2001.B8 (VDD), U2001.B10 (VDD), U2001.B12 (VDD), U2001.B14 (VDD), U2001.B16 (VDD), U2001.B18 (VDD), U2001.B20 (VDD), U2001.B22 (VDD), U2001.B24 (VDD), U2001.B26 (VDD), U2001.B28 (VDD), U2001.B30 (VDD)
unnamed: U2001.B2 (VDDR), U2001.B4 (VDDR)
unnamed: U2001.C33 (FBVDD), U2001.C34 (FBVDD), U2001.C36 (FBVDD), U2001.C37 (FBVDD), U2001.C38 (FBVDD), U2001.C39 (FBVDD), U2001.C40 (FBVDD)
unnamed: U2001.C7 (VDD), U2001.C9 (VDD), U2001.C11 (VDD), U2001.C13 (VDD), U2001.C15 (VDD), U2001.C17 (VDD), U2001.C19 (VDD), U2001.C21 (VDD), U2001.C23 (VDD), U2001.C25 (VDD), U2001.C27 (VDD), U2001.C29 (VDD), U2001.C31 (VDD)
unnamed: U2001.D34 (FBVDD), U2001.D35 (FBVDD), U2001.D38 (FBVDD), U2001.D39 (FBVDD), U2001.D40 (FBVDD)
unnamed: U2001.D6 (VDD), U2001.D8 (VDD), U2001.D10 (VDD), U2001.D12 (VDD), U2001.D14 (VDD), U2001.D16 (VDD), U2001.D18 (VDD), U2001.D20 (VDD), U2001.D22 (VDD), U2001.D24 (VDD), U2001.D26 (VDD), U2001.D28 (VDD), U2001.D30 (VDD)
unnamed: U2001.E32 (FBVDD), U2001.E33 (FBVDD), U2001.E36 (FBVDD), U2001.E37 (FBVDD), U2001.E39 (FBVDD)
unnamed: U2001.E7 (VDD), U2001.E9 (VDD), U2001.E11 (VDD), U2001.E13 (VDD), U2001.E15 (VDD), U2001.E17 (VDD), U2001.E19 (VDD), U2001.E21 (VDD), U2001.E23 (VDD), U2001.E25 (VDD), U2001.E27 (VDD), U2001.E29 (VDD), U2001.E31 (VDD)
unnamed: U2001.F35 (FBVDD), U2001.F36 (FBVDD), U2001.F38 (FBVDD), U2001.F39 (FBVDD), U2001.F40 (FBVDD), U2001.F41 (FBVDD)
unnamed: U2001.F6 (VDD), U2001.F8 (VDD), U2001.F10 (VDD), U2001.F12 (VDD), U2001.F14 (VDD), U2001.F16 (VDD), U2001.F18 (VDD), U2001.F20 (VDD), U2001.F22 (VDD), U2001.F24 (VDD), U2001.F26 (VDD), U2001.F28 (VDD), U2001.F30 (VDD)
unnamed: U2001.G33 (FBVDD), U2001.G34 (FBVDD), U2001.G36 (FBVDD), U2001.G37 (FBVDD), U2001.G38 (FBVDD), U2001.G39 (FBVDD), U2001.G40 (FBVDD)
unnamed: R2061.1, U2001.G1 (FB_ZQ2)
unnamed: U2001.G9 (VDD), U2001.G11 (VDD), U2001.G13 (VDD), U2001.G15 (VDD), U2001.G17 (VDD), U2001.G19 (VDD), U2001.G21 (VDD), U2001.G23 (VDD), U2001.G25 (VDD), U2001.G27 (VDD), U2001.G29 (VDD), U2001.G31 (VDD)
unnamed: R2067.2, U2001.H40 (FBCAL0_PD_VD)
unnamed: U2001.H10 (VDD), U2001.H12 (VDD), U2001.H14 (VDD), U2001.H16 (VDD), U2001.H18 (VDD), U2001.H20 (VDD), U2001.H22 (VDD), U2001.H24 (VDD), U2001.H26 (VDD), U2001.H28 (VDD), U2001.H30 (VDD)
unnamed: R2070.2, U2001.J39 (FBCAL0_TERM_GND)
unnamed: R2068.2, U2001.K39 (FBCAL0_PU_GND)
unnamed: U2001.K35 (FBVDD), U2001.K36 (FBVDD)
unnamed: U2001.K13 (VDD), U2001.K15 (VDD), U2001.K17 (VDD), U2001.K19 (VDD), U2001.K21 (VDD), U2001.K23 (VDD), U2001.K25 (VDD), U2001.K27 (VDD), U2001.K29 (VDD)
unnamed: R2071.1, U2001.L41 (FB_ZQ1)
unnamed: U2001.M14 (VDD), U2001.M16 (VDD), U2001.M18 (VDD), U2001.M20 (VDD), U2001.M22 (VDD), U2001.M24 (VDD), U2001.M26 (VDD), U2001.M28 (VDD)
unnamed: U2001.P14 (VDD), U2001.P16 (VDD), U2001.P18 (VDD), U2001.P20 (VDD), U2001.P22 (VDD), U2001.P24 (VDD), U2001.P26 (VDD), U2001.P28 (VDD)
unnamed: U2001.R15 (VDD), U2001.R17 (VDD), U2001.R19 (VDD), U2001.R21 (VDD), U2001.R23 (VDD), U2001.R25 (VDD), U2001.R27 (VDD), U2001.R30 (VDD)
unnamed: U2001.V14 (VDD), U2001.V18 (VDD), U2001.V20 (VDD), U2001.V22 (VDD), U2001.V24 (VDD), U2001.V28 (VDD), U2001.V32 (GND)
unnamed: U2001.W15 (VDD), U2001.W19 (VDD), U2001.W21 (VDD), U2001.W23 (VDD), U2001.W27 (VDD)
unnamed: U2001.Y14 (VDD), U2001.Y18 (VDD), U2001.Y20 (VDD), U2001.Y22 (VDD), U2001.Y24 (VDD), U2001.Y28 (VDD)
RSX_AVCLK0: U2001.AY32 (AVCLKO); also elsewhere on the board
RSX_AVCLK1: U2001.AY34 (AVCLK1); also elsewhere on the board
RSX_AVCLK2: U2001.AW33 (AVCLK2); also elsewhere on the board
RSX_AVCLK3: U2001.BA34 (AVCLK3); also elsewhere on the board
RSX_FB_VDD_VREF2: U2001.E2 (FB_VDDVREF2)
RSX_FB_VREF2: U2001.E1 (FB_VREF2)
RSX_FB_VREF4: U2001.AY35 (FB_VREF4)
RSX_GPIO0: U2001.AW17 (GPIO0); also elsewhere on the board
RSX_GPIO1: U2001.AW16 (GPIO1); also elsewhere on the board
RSX_GPIO2: U2001.AY16 (GPIO2); also elsewhere on the board
RSX_GPIO3: U2001.AV16 (GPIO3); also elsewhere on the board
RSX_GPIO4: U2001.AY15 (GPIO4)
RSX_GPIO5: U2001.AY14 (GPIO5); also elsewhere on the board
RSX_GPIO6: U2001.AV14 (GPIO6); also elsewhere on the board
RSX_GPIO7: U2001.BA14 (GPIO7); also elsewhere on the board
RSX_HSYNCI: U2001.Y38 (HSYNCI)
RSX_HSYNCO0: U2001.BA22 (HSYNCO0); also elsewhere on the board
RSX_HTPLGIN: U2001.W36 (HTPLGI)
RSX_NTPLO1: U2001.AA37 (NTPL01)
RSX_PCLKI: U2001.R38 (PCLKI)
RSX_RC_REFCLK_N: U2001.AP2 (REFCLKN)
RSX_RC_REFCLK_P: U2001.AP1 (REFCLKP)
RSX_SPI_DO: U2001.BA6 (MOSI0); also elsewhere on the board
RSX_SUBPCLK0: U2001.BA26 (SUBPCLK0); also elsewhere on the board
RSX_VDDMONI: U2001.B31 (VDDMON)
RSX_VI12: U2001.R36 (VI12); also elsewhere on the board
RSX_VI14: U2001.R37 (VI14); also elsewhere on the board
RSX_VI15: U2001.T38 (VI15); also elsewhere on the board
RSX_VI16: U2001.P35 (VI16); also elsewhere on the board
RSX_VI17: U2001.T40 (VI17); also elsewhere on the board
RSX_VI18: U2001.P38 (VI18); also elsewhere on the board
RSX_VI19: U2001.T39 (VI19); also elsewhere on the board
RSX_VI20: U2001.P36 (VI20); also elsewhere on the board
RSX_VI21: U2001.N36 (VI21); also elsewhere on the board
RSX_VI22: U2001.R40 (VI22); also elsewhere on the board
RSX_VI23: U2001.M35 (VI23); also elsewhere on the board
RSX_VI24: U2001.P41 (VI24); also elsewhere on the board
RSX_VI25: U2001.P40 (VI25); also elsewhere on the board
RSX_VI26: U2001.P39 (VI26); also elsewhere on the board
RSX_VI27: U2001.N37 (VI27); also elsewhere on the board
RSX_VI28: U2001.N39 (VI28); also elsewhere on the board
RSX_VI29: U2001.L36 (VI29); also elsewhere on the board
RSX_VI30: U2001.M38 (VI30); also elsewhere on the board
RSX_VI31: U2001.L37 (VI31); also elsewhere on the board
RSX_VI32: U2001.M40 (VI32); also elsewhere on the board
RSX_VI33: U2001.L38 (VI33); also elsewhere on the board
RSX_VI34: U2001.L40 (VI34); also elsewhere on the board
RSX_VI35: U2001.M39 (VI35); also elsewhere on the board
RSX_VO2: U2001.AY23 (VO_002); also elsewhere on the board
RSX_VO3: U2001.AV24 (VO_003); also elsewhere on the board
RSX_VO4: U2001.AY24 (VO_004); also elsewhere on the board
RSX_VO05: U2001.AU25 (VO_005)
RSX_VO6: U2001.AW24 (VO_006); also elsewhere on the board
RSX_VO8: U2001.AW25 (VO_008); also elsewhere on the board
RSX_VO11: U2001.AU27 (VO_011); also elsewhere on the board
RSX_VO15: U2001.AY26 (VO_015); also elsewhere on the board
RSX_VO17: U2001.AY27 (VO_017); also elsewhere on the board
RSX_VO18: U2001.AU29 (VO_018); also elsewhere on the board
RSX_VO22: U2001.AY28 (VO_022); also elsewhere on the board
RSX_VO23: U2001.AU31 (VO_023); also elsewhere on the board
RSX_VO30: U2001.AY30 (VO_030); also elsewhere on the board
RSX_VO32: U2001.BA30 (VO_032); also elsewhere on the board
RSX_VO35: U2001.AY31 (VO_035); also elsewhere on the board
RSX_VO36: U2001.AH35 (VO_100); also elsewhere on the board
RSX_VO38: U2001.AK41 (VO_102); also elsewhere on the board
RSX_VO39: U2001.AK39 (VO_103); also elsewhere on the board
RSX_VO41: U2001.AG36 (VO_105); also elsewhere on the board
RSX_VO42: U2001.AH38 (VO_106); also elsewhere on the board
RSX_VO43: U2001.AG37 (VO_107); also elsewhere on the board
RSX_VO44: U2001.AH40 (VO_108); also elsewhere on the board
RSX_VO45: U2001.AG38 (VO_109); also elsewhere on the board
RSX_VO46: U2001.AH39 (VO_110); also elsewhere on the board
RSX_VO47: U2001.AF35 (VO_111); also elsewhere on the board
RSX_VO48: U2001.AF38 (VO_112); also elsewhere on the board
RSX_VO49: U2001.AG40 (VO_113); also elsewhere on the board
RSX_VO50: U2001.AF36 (VO_114); also elsewhere on the board
RSX_VO51: U2001.AF40 (VO_115); also elsewhere on the board
RSX_VO52: U2001.AD35 (VO_116); also elsewhere on the board
RSX_VO53: U2001.AF39 (VO_117); also elsewhere on the board
RSX_VO54: U2001.AE37 (VO_118); also elsewhere on the board
RSX_VO55: U2001.AE39 (VO_119); also elsewhere on the board
RSX_VO56: U2001.AC36 (VO_120); also elsewhere on the board
RSX_VO57: U2001.AC37 (VO_121); also elsewhere on the board
RSX_VO58: U2001.AD38 (VO_122); also elsewhere on the board
RSX_VO59: U2001.AC38 (VO_123); also elsewhere on the board
RSX_VO60: U2001.AD40 (VO_124); also elsewhere on the board
RSX_VO61: U2001.AD39 (VO_125); also elsewhere on the board
RSX_VO62: U2001.AC40 (VO_126); also elsewhere on the board
RSX_VO63: U2001.AB35 (VO_127); also elsewhere on the board
RSX_VO64: U2001.AB41 (VO_128); also elsewhere on the board
RSX_VO65: U2001.AB38 (VO_129); also elsewhere on the board
RSX_VO66: U2001.AB40 (VO_130); also elsewhere on the board
RSX_VO67: U2001.AB36 (VO_131); also elsewhere on the board
RSX_VO68: U2001.AB39 (VO_132); also elsewhere on the board
RSX_VO69: U2001.AA36 (VO_133); also elsewhere on the board
RSX_VO70: U2001.Y35 (VO_134); also elsewhere on the board
RSX_VO71: U2001.AA39 (VO_135); also elsewhere on the board
RSX_VO_DE1: U2001.AL40 (DE1); also elsewhere on the board
RSX_VO_EE0: U2001.AY22 (DE0)
RSX_VO_VINTE1: U2001.AL38 (VINTE1)
RSX_VSSMONI: U2001.A31 (VSSMON)
RSX_VSYNCI: U2001.W38 (VSYNCI)
RS_BCLKO: R2064.1; also elsewhere on the board
RS_LRCKI1: U2001.AU17 (LRCKI1)
RS_LRCKO: R2063.1; also elsewhere on the board
RS_SDOUT1: R2065.1; also elsewhere on the board
RS_SPMCLKI: U2001.AU19 (SPMCLKI)
RS_TCK: U2001.AU13 (JTAG_TCK); also elsewhere on the board
RS_TDI: U2001.AT16 (JTAG_TDI); also elsewhere on the board
RS_TMS: U2001.AR14 (JTAG_TMS); also elsewhere on the board
TS_TDO: U2001.AR16 (JTAG_TDO); also elsewhere on the board
~RS_TRSTNEG: U2001.AU15 (JTAG_TRST_N); also elsewhere on the board

Schematic: dcdc.kicad_sch

Parts:
C6310, C6316: 100p 50V; C_0402_1005Metric
C6320, C6322: 22u 16V; C_1210_3225Metric
C6355, C6356: 10u 6.3V; C_0805_2012Metric
C6358, C6359: 0.1u 10V; C_0402_1005Metric
C6362: 1u 10V; C_0603_1608Metric
C6365: 0.022u 16V; C_0402_1005Metric
F6302, F6303, F6304: 5A; Fuse_1206_3216Metric
FB6302: FerriteBead_Small; R_0603_1608Metric
L6302, L6303: 1uH; L_TDK_SLF6028
L6305, L6306: 1.4uH; L_TDK_SLF12555
Q6301: FDQ7238AS; SO-14_3.9x8.65mm_P1.27mm
Q6302, Q6303, Q6306, Q6307: SI4336; SSOP-8_3.9x5.05mm_P1.27mm
Q6304, Q6305: SI4392; SSOP-8_3.9x5.05mm_P1.27mm
Q6308: IRF7607PBF; SSOP-8_3.9x5.05mm_P1.27mm
Q6309: SI4866DY; SSOP-8_3.9x5.05mm_P1.27mm
Q6310, Q6600: SUD40N02; TO-252-2
Q6311: UMH2NTN; SOT-363_SC-70-6
R6304, R6309, R6619, R6621, R6622, R6623: 10k; R_0402_1005Metric
R6355: 220; R_0402_1005Metric
R6368: 0; R_0402_1005Metric
R6605: 3300; R_0402_1005Metric
R6608: 180; R_0402_1005Metric
TP9648, TP9655: TestPoint; TestPoint_Pad_1.0x1.0mm
U6301: SN105233DBTR; TSSOP-30_4.4x7.8mm_P0.5mm
U6302: TPS51117; TSSOP-14_4.4x5mm_P0.65mm
U6303, U6305: BD3520FVM-TR; MSOP-8_2.9x4mm_P0.65mm
U6304, U6602: BD3504FVM-TR; MSOP-8_2.9x4mm_P0.65mm
U6600: MM3143; TSOP-5_1.65x3.05mm_P0.95mm
U6601: NCP511; TSOP-5_1.65x3.05mm_P0.95mm
U6603, U6606: MM1561; SSOP-8_3.9x5.05mm_P1.27mm
U6604: XX; TSOP-5_1.65x3.05mm_P0.95mm; not fitted
U6605: MM1573; TSOP-5_1.65x3.05mm_P0.95mm
U6607: MM1662; SSOP-8_3.9x5.05mm_P1.27mm

Connections:
+1.2V_EEGS_VDD: Q6600.3 (S), U6602.6 (VS)
+1.2V_SB_VDDA: FB6302.1; also elsewhere on the board
+1.2V_SB_VDDC: C6356.1, FB6302.2, Q6309.5 (D), Q6309.6 (D), Q6309.7 (D), Q6309.8 (D), TP9648.1 (1_1), U6305.6 (VS); also elsewhere on the board
+1.2V_YC_RC_VDDIO: Q6310.3 (S), U6303.6 (VS); also elsewhere on the board
+1.5V_EEGS_VDD0: U6606.1 (Vout)
+1.5V_YC_RC_VDDA: Q6308.5 (D), Q6308.6 (D), Q6308.7 (D), Q6308.8 (D), TP9655.1 (1_1), U6304.6 (VS)
+1.7V_MISC: F6303.1, Q6309.1 (S), Q6309.2 (S), Q6309.3 (S), Q6310.2 (D), R6368.2; also elsewhere on the board
+1.8V_EEGS_VDDIO: U6603.1 (Vout); also elsewhere on the board
+1.8V_RDRAM_VCMOS: U6604.5 (Vout)
+2.5V_EEGS_PLLVDD1: U6601.5 (Vout)
+2.5V_RDRAM_VDD: U6607.1 (Vout)
+3.1V_EEGS_AVDA: U6600.5 (Vout)
+3.3V_DRCG_VDD: U6605.5 (Vout)
+3.3V_EVER: R6304.2; also elsewhere on the board
+3.3V_MISC: R6309.2, U6601.1 (Vin), U6603.8 (Vin), U6604.1 (Vin), U6606.8 (Vin), U6607.8 (Vin); also elsewhere on the board
+5V_EVER: F6304.1; also elsewhere on the board
+5V_MISC: C6362.1, U6303.4 (VCC), U6304.4 (VCC), U6305.4 (VCC), U6600.1 (Vin), U6602.4 (VCC), U6605.1 (Vin); also elsewhere on the board
+12V_MAIN: F6302.1; also elsewhere on the board
GND: C6310.2, C6316.2, C6320.2, C6322.2, C6355.2, C6356.2, C6358.1, C6359.1, C6362.2, C6365.2, Q6301.5 (D), Q6301.6, Q6301.7, Q6303.1 (S), Q6303.2 (S), Q6303.3 (S), Q6307.1 (S), Q6307.2 (S), Q6307.3 (S), Q6311.1 (E1), Q6311.4 (E2), R6619.1, R6621.1, R6622.1, R6623.1, U6302.7 (GND_7), U6303.2 (GND), U6304.2 (GND), U6305.2 (GND), U6600.2 (GND), U6601.2 (GND), U6602.2 (GND), U6603.2 (NC), U6603.3 (GND), U6603.6 (SUB), U6603.7 (SUB), U6604.2 (GND), U6605.2 (GND), U6606.2 (NC), U6606.3 (GND), U6606.6 (SUB), U6606.7 (SUB), U6607.2 (NC), U6607.3 (GND), U6607.6 (SUB), U6607.7 (SUB); also elsewhere on the board
unnamed: C6320.1, C6322.1, L6302.2, Q6305.5 (D), Q6305.6 (D), Q6305.7 (D), Q6305.8 (D)
unnamed: C6355.1, F6303.2, Q6308.1 (S), Q6308.2 (S), Q6308.3 (S)
unnamed: C6365.1, R6355.1
unnamed: F6302.2, L6302.1
unnamed: F6304.2, L6303.1
unnamed: L6303.2, Q6301.1 (S), Q6301.2 (S)
unnamed: L6305.1 (1_1), Q6302.5 (D), Q6302.6 (D), Q6302.7 (D), Q6302.8 (D), Q6304.1 (S), Q6304.2 (S), Q6304.3 (S), Q6306.5 (D), Q6306.6 (D), Q6306.7 (D), Q6306.8 (D)
unnamed: L6306.1 (1_1), Q6303.5 (D), Q6303.6 (D), Q6303.7 (D), Q6303.8 (D), Q6305.1 (S), Q6305.2 (S), Q6305.3 (S), Q6307.5 (D), Q6307.6 (D), Q6307.7 (D), Q6307.8 (D)
unnamed: Q6301.8, Q6301.9, Q6301.10, Q6301.11, Q6301.12, Q6301.13, Q6301.14
unnamed: Q6302.4 (G), Q6306.4 (G)
unnamed: Q6302.1 (S), Q6302.2 (S), Q6302.3 (S)
unnamed: Q6304.5 (D), Q6304.6 (D), Q6304.7 (D), Q6304.8 (D)
unnamed: Q6306.1 (S), Q6306.2 (S), Q6306.3 (S)
unnamed: Q6308.4 (G), U6304.7 (G)
unnamed: Q6309.4 (G), R6355.2, U6305.7 (G)
unnamed: Q6310.1 (G), U6303.7 (G)
unnamed: Q6311.6 (C1), R6304.1
unnamed: Q6311.3 (C2), R6309.1
unnamed: Q6600.2 (D), R6608.2
unnamed: Q6600.1 (G), U6602.7 (G)
unnamed: R6605.2, R6608.1
unnamed: R6368.1, U6303.8 (VD)
unnamed: C6358.2, U6304.1 (NACS)
unnamed: C6359.2, U6305.1 (NACS)
unnamed: R6605.1, U6602.8 (VD)
SW2.5: R6619.2, U6601.3 (Enable); also elsewhere on the board
SW3.1: R6622.2, U6600.3 (Enable); also elsewhere on the board
SW3.3: R6621.2, U6605.3 (Enable); also elsewhere on the board
SW_1.2: R6623.2, U6602.3 (EN)
SW_3: C6310.1, U6305.3 (EN); also elsewhere on the board
SW_6: U6303.3 (EN); also elsewhere on the board
SW_8_A: C6316.1, U6304.3 (EN); also elsewhere on the board

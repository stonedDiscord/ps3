# Repository stonedDiscord/ps3 (continued)

## KiCad design cok-001/cok-001.kicad_pcb (continued)

Schematic: syscon.kicad_sch

Parts:
BZ4001: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C4025, C4026: 15p; C_0402_1005Metric
C4027, C4028: 15p; C_0402_1005Metric; not fitted
C4031: 100u 16V; CP_Elec_5x3.9
C4032, C4047, C4050, C4051, C4052, C4053, C4054, C4058, C4062: 0.001u 50V; C_0402_1005Metric
C4049: 1u 10V; C_0603_1608Metric
C4067: 0.01u; C_0402_1005Metric
C4068: 0.1u; C_0402_1005Metric
C4069: 4.7u; C_0603_1608Metric
D4006: Thermal LED; LED_0603_1608Metric; not fitted
D4007, D4008, D4009: RB751; D_SOD-923
D4010: EDZCTE616; D_SOD-923
FB4001: 0uH; L_0603_1608Metric
J4001: FAN; JST_PH_B3B-PH-SM4-TB_1x03-1MP_P2.00mm_Vertical
J4003: Conn_01x02_Pin; PinHeader_1x02_P1.27mm_Vertical_SMD_Pin1Left
J4009: Conn_01x30_Socket; TE_3-1734839-0_1x30-1MP_P0.5mm_Horizontal
J4010: BUTTONS; ConnectorMicromatch-10
JL4006, JL4007: TestPoint; TestPoint_Pad_D1.5mm
Q4008: DTC144E; SOT-323_SC-70
Q4011: DTC143ZUA; SOT-323_SC-70; not fitted
Q4012, Q4013: UMH2NTN; SOT-363_SC-70-6; not fitted
Q4014, Q4015: DTC143ZUA; SOT-323_SC-70
R1101, R4037, R4049: 4700; R_0402_1005Metric
R4002, R4030, R4031: 33; R_0402_1005Metric
R4003, R4004, R4006, R4007, R4008, R4010, R4011, R4012, R4106, R4107: 47; R_0402_1005Metric
R4025, R4026, R4027, R4028, R4043, R4104, R4105: 22; R_0402_1005Metric
R4041: 2200; R_0402_1005Metric
R4042: 1M; R_0402_1005Metric
R4044: 1k; R_0402_1005Metric
R4080, R4120, R4124: XX; R_0402_1005Metric; not fitted
R4088, R4089, R4114, R4138, R4139, R4140: 0; R_0402_1005Metric
R4118: XX; R_0603_1608Metric; not fitted
R4128: 1k; R_0603_1608Metric
R4129: 10k; R_0402_1005Metric
RN4001, RN4002, RN4003: 10k; R_Array_Convex_4x0402
RN4004, RN4005, RN4006, RN4007: 22; R_Array_Convex_4x0402
TP4001, TP4002, TP4003, TP4004, TP4005, TP4006, TP4007, TP4008, TP4009, TP4010, TP4011, TP4012, TP4016, TP4020, TP4021, TP4022, TP4034, TP4035, TP4036, TP4040, TP4044, TP4046, TP4075, TP4080, TP4081, TP4082, TP4083, TP4084, TP4085, TP4086, TP4087, TP4089, TP4090, TP4091, TP4092, TP4093, TP4094, TP4096, TP4097, TP4099, TP4100, TP4101, TP4105, TP4106, TP9408, TP9409, TP40005: TestPoint; TestPoint_Pad_1.0x1.0mm
TP9401, TP9402, TP9405, TP9406, TP9407: TestPoint; TestPoint_Pad_D1.5mm
U4002: SYSCON
U4003, U4004, U4005: 74LVC2G34; SOT-363_SC-70-6; not fitted
U4006: 74LVC1G34; SOT-353_SC-70-5; not fitted
Y4001: 16.9344MHz; Crystal_SMD_FOX_FQ7050-2Pin_7.0x5.0mm
Y4002: 32.768kHz; Crystal_SMD_SeikoEpson_MC156-4Pin_7.1x2.5mm

Connections:
+1.2V_MC2_VDDIO: U4003.5 (VCC); also elsewhere on the board
+1.5V_RSX_VDDIO: U4004.5 (VCC); also elsewhere on the board
+3.3V_EVER: R4124.1, U4005.5 (VCC), U4006.5 (VCC); also elsewhere on the board
+5V_EVER: BZ4001.2 (-), R4118.1, R4128.2; also elsewhere on the board
+12V_MAIN: C4031.1, C4032.1, FB4001.1, TP9409.1 (1_1); also elsewhere on the board
ACDC_STBY: U4002.A11 (ACDC_STBY); also elsewhere on the board
AUDIO_MUTE: U4002.N6 (~AUDIO_MUTE); also elsewhere on the board
BD_LED: Q4015.1 (B), R4080.1; also elsewhere on the board
BEVRM_VID0: RN4005.5 (R4.2); also elsewhere on the board
BEVRM_VID1: RN4005.6 (R3.2); also elsewhere on the board
BEVRM_VID2: RN4004.7 (R2.2); also elsewhere on the board
BEVRM_VID3: RN4004.8 (R1.2); also elsewhere on the board
BEVRM_VID4: RN4004.6 (R3.2); also elsewhere on the board
BEVRM_VID5: RN4004.5 (R4.2); also elsewhere on the board
BE_POWGOOD: R4107.1; also elsewhere on the board
BE_TRG_IN: U4003.4; also elsewhere on the board
BE_TRG_OUT: U4003.1; also elsewhere on the board
DISC_CHUCK: Q4012.5 (B2); also elsewhere on the board
DISC_IN_MECHA: U4002.F5 (DISC_IN_MECHA); also elsewhere on the board
DVE_I2C_SCL: R4105.2; also elsewhere on the board
DVE_I2C_SDA: R4104.2; also elsewhere on the board
EJECT_MECHA: U4002.E4 (EJECT_MECHA); also elsewhere on the board
GND: C4025.2, C4026.2, C4027.2, C4028.2, C4031.2, C4032.2, C4047.2, C4049.1, C4050.2, C4051.2, C4052.2, C4053.2, C4054.2, C4058.2, C4062.2, C4067.2, C4068.2, C4069.2, D4010.2 (A), J4001.2, J4003.2, J4009.9, J4009.12, J4009.29, J4010.2, J4010.10, Q4008.2 (E), Q4011.2 (E), Q4012.1 (E1), Q4012.4 (E2), Q4013.4 (E2), Q4014.2 (E), Q4015.2 (E), R4129.2, RN4001.5 (R4.2), RN4001.6 (R3.2), RN4001.7 (R2.2), RN4001.8 (R1.2), RN4002.5 (R4.2), RN4002.6 (R3.2), RN4002.7 (R2.2), RN4002.8 (R1.2), RN4003.5 (R4.2), RN4003.6 (R3.2), RN4003.7 (R2.2), RN4003.8 (R1.2), TP9408.1 (1_1), U4002.C2 (AvRef2), U4002.C15 (VSSep), U4002.E1 (Vss), U4002.G6 (AVss), U4002.G7 (Vss), U4002.G8 (Vss), U4002.G10 (Vss), U4002.L1 (Vss), U4002.R4 (AVSUO), U4002.R6 (Vss), U4002.T3 (Vss), U4002.T6 (Vss), U4003.2 (GND), U4004.2 (GND), U4005.2 (GND), U4006.3 (GND); also elsewhere on the board
HDMI_I2C_SCL: R4028.1; also elsewhere on the board
HDMI_I2C_SDA: R4027.1; also elsewhere on the board
MC_ALIVE: Q4012.2 (B1), U4002.A7 (MC_ALIVE); also elsewhere on the board
MC_P_OFF_REQ: U4002.B6 (MC_P_OFF_REQ); also elsewhere on the board
MC_RESERVED1: U4002.B7 (MC_RESERVED1)
MK_I2C_SCL: R4026.1; also elsewhere on the board
MK_I2C_SDA: R4025.1; also elsewhere on the board
unnamed: BZ4001.1 (+), Q4014.3 (C), R4128.1
unnamed: C4026.1, R4041.2, Y4001.1
unnamed: D4006.2 (A), R4118.2
unnamed: D4006.1 (K), Q4011.3 (C)
unnamed: D4007.2 (A), J4003.1, TP40005.1 (1_1)
unnamed: D4007.1 (K), D4008.2 (A)
unnamed: C4067.1, C4068.1, C4069.1, D4008.1 (K), D4009.1 (K), U4002.F11 (Vddbat)
unnamed: D4009.2 (A), R4044.2, R4049.2, U4002.B1 (AvRef1), U4002.F6 (Vdd3), U4002.F7 (AVdd), U4002.F8 (Vdd3), U4002.F10 (Vdd3), U4002.G11 (VDDep), U4002.H10 (Vdd3), U4002.J6 (Vdd3), U4002.L6 (VddF), U4002.R5 (AVDUO)
unnamed: D4010.1 (K), J4001.3, Q4011.1 (B), TP9407.1 (1_1), U4002.N8 (FANPWM0)
unnamed: FB4001.2, J4001.1
unnamed: J4009.2, TP4007.1 (1_1)
unnamed: J4009.3, TP4008.1 (1_1)
unnamed: J4009.4, TP4036.1 (1_1)
unnamed: J4009.5, TP4035.1 (1_1)
unnamed: J4009.6, TP4034.1 (1_1)
unnamed: J4009.7, TP4009.1 (1_1)
unnamed: J4009.8, TP4090.1 (1_1)
unnamed: J4009.10, TP4080.1 (1_1)
unnamed: J4009.11, TP4081.1 (1_1)
unnamed: J4009.13, TP4082.1 (1_1)
unnamed: J4009.14, TP4083.1 (1_1)
unnamed: J4009.16, TP4105.1 (1_1)
unnamed: J4009.17, R4120.1, U4002.R10 (RMC_IN)
unnamed: C4049.2, J4010.1
unnamed: C4054.1, J4010.3, Q4013.3 (C2), Q4015.3 (C)
unnamed: C4053.1, J4010.4, U4002.N7 (STBY_LED)
unnamed: C4052.1, J4010.5, U4002.M7 (POW_LED)
unnamed: C4051.1, J4010.6, JL4006.1 (1_1), U4002.A12 (~EJECT_SW)
unnamed: C4050.1, J4010.7, JL4007.1 (1_1), U4002.B12 (~POW_SW)
unnamed: J4010.8, R4120.2
unnamed: C4062.1, J4010.9, U4002.N9 (SW_PWM)
unnamed: Q4008.1 (B), U4002.M10 (~XDR_FET_VREF)
unnamed: Q4012.3 (C2), Q4012.6 (C1), Q4013.1 (E1), Q4013.5 (B2)
unnamed: Q4013.6 (C1), R4124.2
unnamed: Q4014.1 (B), U4002.M9 (BUZZER)
unnamed: R1101.2, R4037.2
unnamed: R4030.2, U4002.T9 (SEL2_I2C_SDA)
unnamed: R4031.2, U4002.T8 (SEL2_I2C_SCL)
unnamed: R4104.1, U4002.B10 (SEL2_I2C_SDA)
unnamed: R4105.1, U4002.A10 (SEL2_I2C_SCL)
unnamed: RN4001.1 (R1.1), U4002.A3 (SW_0)
unnamed: RN4001.2 (R2.1), U4002.F13 (SW_5_B)
unnamed: R4138.1, RN4001.3 (R3.1), U4002.D13 (SW_1A)
unnamed: R4139.1, RN4001.4 (R4.1), U4002.R13 (SW_1_B)
unnamed: RN4004.1 (R1.1), U4002.H13 (BEVRM_VID3)
unnamed: RN4004.2 (R2.1), U4002.H12 (BEVRM_VID2)
unnamed: RN4004.3 (R3.1), U4002.G12 (BEVRM_VID4)
unnamed: RN4004.4 (R4.1), U4002.G13 (BEVRM_VID5)
unnamed: RN4005.2 (R2.1), U4002.R14 (SW_7_A)
unnamed: RN4005.3 (R3.1), U4002.J13 (BEVRM_VID1)
unnamed: RN4005.4 (R4.1), U4002.J12 (BEVRM_VID0)
unnamed: RN4006.1 (R1.1), U4002.N13 (RSXVRM_VID1)
unnamed: RN4006.2 (R2.1), U4002.M13 (RSXVRM_VID3)
unnamed: RN4006.3 (R3.1), U4002.L12 (RSXVRM_VID4)
unnamed: RN4006.4 (R4.1), U4002.L13 (RSXVRM_VID5)
unnamed: RN4007.1 (R1.1), U4002.N4 (SW_5_A)
unnamed: RN4007.2 (R2.1), U4002.R8 (RSX_FBVDD_SEL)
unnamed: RN4007.3 (R3.1), U4002.M12 (RSXVRM_VID2)
unnamed: RN4007.4 (R4.1), U4002.N12 (RSXVRM_VID0)
unnamed: R4043.1, U4002.D15 (32KIN)
unnamed: R4043.2, R4044.1, U4002.D16 (32KOUT)
unnamed: R1101.1, TP9406.1 (1_1), U4002.N15 (BACKUP_MODE)
unnamed: R4107.2, U4002.P1 (BE_POWGOOD)
unnamed: R4008.1, U4002.N1 (BE_SPI_CLK)
unnamed: R4007.1, U4002.N2 (BE_SPI_DO)
unnamed: R4049.1, U4002.F15 (PP0), U4002.F16 (CSB)
unnamed: U4002.G15 (PP2), U4002.G16 (DI)
unnamed: R4037.1, TP9405.1 (1_1), U4002.N16 (DIAG_MODE)
unnamed: U4002.H15 (PP1), U4002.H16 (DO)
unnamed: U4002.H7 (DVdd), U4002.J7 (DVdd), U4002.J10 (DVdd), U4002.K10 (DVdd), U4002.L10 (DVdd), U4002.L11 (DVdd), U4002.R7 (DVdd)
unnamed: C4025.1, R4042.2, U4002.T5 (EXTAL), Y4001.2
unnamed: TP4044.1 (1_1), U4002.M8 (FANPWM1)
unnamed: TP4097.1 (1_1), U4002.G4 (HDMI_RST1)
unnamed: TP4106.1 (1_1), U4002.K12 (I2CBUS_EN)
unnamed: TP4001.1 (1_1), U4002.L7 (JNTRST)
unnamed: TP4006.1 (1_1), U4002.L8 (JRTCK)
unnamed: TP4005.1 (1_1), U4002.K8 (JTCK)
unnamed: TP4002.1 (1_1), U4002.K7 (JTDI)
unnamed: TP4004.1 (1_1), U4002.K9 (JTDO)
unnamed: TP4003.1 (1_1), U4002.L9 (JTMS)
unnamed: R4080.2, U4002.A6 (MC_RESERVED2)
unnamed: C4027.1, U4002.C16 (OSCIN), Y4002.1
unnamed: C4028.1, U4002.B16 (OSCOUT), Y4002.4
unnamed: TP4092.1 (1_1), U4002.M4 (PA0)
unnamed: TP4087.1 (1_1), U4002.M6 (PA4)
unnamed: TP4085.1 (1_1), U4002.K13 (PC7)
unnamed: TP4094.1 (1_1), U4002.A14 (PE3)
unnamed: TP4046.1 (1_1), U4002.E13 (PF1)
unnamed: TP4075.1 (1_1), U4002.D12 (PF2)
unnamed: U4002.J15 (WCB), U4002.K15 (PI6)
unnamed: U4002.J16 (RBB), U4002.K16 (PI7)
unnamed: TP4089.1 (1_1), U4002.B3 (PJ3)
unnamed: TP4093.1 (1_1), U4002.B11 (PK0)
unnamed: TP4010.1 (1_1), U4002.R2 (PM6)
unnamed: TP4011.1 (1_1), U4002.R1 (PM7)
unnamed: TP4084.1 (1_1), U4002.H1 (PN5)
unnamed: TP4012.1 (1_1), U4002.H2 (PN6)
unnamed: TP4086.1 (1_1), U4002.E5 (PO0)
unnamed: U4002.E15 (PP3), U4002.E16 (SKB)
unnamed: TP4020.1 (1_1), U4002.R9 (PQ1)
unnamed: TP4021.1 (1_1), U4002.T10 (PQ4)
unnamed: TP4022.1 (1_1), U4002.T11 (PQ5)
unnamed: R4012.2, U4002.G1 (RSX_SPI_CLK)
unnamed: R4011.2, U4002.F2 (RSX_SPI_DO)
unnamed: R4004.1, U4002.A8 (SB_SPI_CLK)
unnamed: R4003.1, U4002.B8 (SB_SPI_DO)
unnamed: R4026.2, U4002.D1 (SEL0_I2C_SCL)
unnamed: R4025.2, U4002.C1 (SEL0_I2C_SDA)
unnamed: R4028.2, U4002.R16 (SEL1_I2C_SCL)
unnamed: R4027.2, U4002.R15 (SEL1_I2C_SDA)
unnamed: TP9401.1 (1_1), U4002.P15 (UART0_RXD)
unnamed: TP9402.1 (1_1), U4002.P16 (UART0_TXD)
unnamed: TP4099.1 (1_1), U4002.B14 (VD_CECI1)
unnamed: TP4100.1 (1_1), U4002.R11 (VD_CECO0)
unnamed: TP4101.1 (1_1), U4002.T12 (VD_CECO1)
unnamed: U4002.K6 (VssF), U4002.K11 (VssF)
unnamed: R4041.1, R4042.1, U4002.T4 (XTAL)
unnamed: TP4040.1 (1_1), U4002.T7 (XXTAL0)
unnamed: R4106.1, U4002.P2 (~BE_RESET)
unnamed: R4006.1, U4002.M2 (~BE_SPI_CS)
unnamed: TP4096.1 (1_1), U4002.E10 (~MUL_CHKSTP_OUT)
unnamed: U4002.D10 (~MUL_TRG_OUT), U4006.2
unnamed: C4047.1, R4114.2, U4002.J11 (~RST)
unnamed: R4010.2, U4002.E2 (~RSX_SPI_CS)
unnamed: R4002.1, U4002.B9 (~SB_SPI_CS)
unnamed: U4003.3, U4003.6, U4004.3, U4004.6, U4005.3, U4005.6, U4006.4
RSX_FBVDD_SEL: RN4007.7 (R2.2)
RSX_FLDO1: U4002.J1 (RSX_FLDO1)
RSX_SPI_CLK: R4012.1
RSX_SPI_DI: U4002.F1 (RSX_SPI_DI)
RSX_SPI_DO: R4011.1; also elsewhere on the board
RXVRM_VID0: RN4007.5 (R4.2)
RXVRM_VID1: RN4006.8 (R1.2)
RXVRM_VID2: RN4007.6 (R3.2)
RXVRM_VID3: RN4006.7 (R2.2)
RXVRM_VID4: RN4006.6 (R3.2)
RXVRM_VID5: RN4006.5 (R4.2)
SB_SPI_CLK: R4004.2; also elsewhere on the board
SB_SPI_DI_M: U4002.A9 (SB_SPI_DI)
SB_SPI_DO: R4003.2
SB_TRG_IN: U4005.4; also elsewhere on the board
SB_TRG_OUT: U4005.1; also elsewhere on the board
SW_1_A: R4138.2; also elsewhere on the board
SW_1_B: R4139.2; also elsewhere on the board
SW_2: RN4002.4 (R4.1), U4002.M15 (SW_2)
SW_3: U4002.R12 (SW_3); also elsewhere on the board
SW_4_A: R4140.1; also elsewhere on the board
SW_4_A_M: R4140.2, RN4003.4 (R4.1), U4002.N11 (SW_4_A)
SW_4_B: RN4003.1 (R1.1), U4002.T13 (SW_4_B); also elsewhere on the board
SW_5_A: RN4007.8 (R1.2); also elsewhere on the board
SW_6: RN4002.2 (R2.1), U4002.T14 (SW_6); also elsewhere on the board
SW_7_A: RN4005.7 (R2.2); also elsewhere on the board
SW_8_A: RN4002.1 (R1.1), U4002.T15 (SW_8_A); also elsewhere on the board
SW_8_B: RN4003.3 (R3.1), U4002.B4 (SW_8_B); also elsewhere on the board
SW_8_C: RN4003.2 (R2.1), U4002.A4 (SW_8_C); also elsewhere on the board
SW_ATA: Q4013.2 (B1), R4129.1, U4002.M11 (SW_ATA); also elsewhere on the board
SW_AVCG: TP4016.1 (1_1), U4002.G5 (PO5); also elsewhere on the board
SW_PCI: RN4002.3 (R3.1), U4002.L16 (SW_PCI); also elsewhere on the board
THR_I2C_SCL: R4031.1; also elsewhere on the board
THR_I2C_SDA: R4030.1; also elsewhere on the board
VD_VINT0: U4002.K1 (~VD_VINT0)
VD_VINT1: U4002.K2 (~VD_VINT1)
XCG_EN: U4002.D5 (XCG_EN); also elsewhere on the board
XDR_RQ_RST: U4002.D4 (~XDR_FET_RST)
XDR_RQ_VREF_FET: Q4008.3 (C); also elsewhere on the board
~11G_RESET: U4002.M5 (~WLAN_REST); also elsewhere on the board
~BE_POW_FAIL: U4002.A15 (~BE_POW_FAIL); also elsewhere on the board
~BT_RESET: U4002.N5 (~BT_RESET); also elsewhere on the board
~DVE_RST: U4002.B5 (~DVE_RST)
~HDMI0_RST: U4002.F4 (HDMI_RST0); also elsewhere on the board
~POW_FAIL: U4002.B15 (~POW_FAIL); also elsewhere on the board
~RSX_INT: C4058.1, U4002.J2 (~RSX_INT); also elsewhere on the board
~RSX_POW_FAIL: U4002.D7 (~RS_POW_FAIL); also elsewhere on the board
~RSX_RESET: U4002.G2 (~RSX_RESET)
~RSX_SPI_CS: R4010.1; also elsewhere on the board
~RSX_TRG_IN: U4004.4; also elsewhere on the board
~RSX_TRG_OUT: U4004.1; also elsewhere on the board
~SB_INT: U4002.D9 (~SB_INT); also elsewhere on the board
~SB_SPI_CS: R4002.2; also elsewhere on the board
~SYSCON_RST: R4114.1, TP4091.1 (1_1); also elsewhere on the board
~SYS_THR_ALRT: R4088.2, R4089.2, U4002.E9 (~SYS_THR_ALRT); also elsewhere on the board
~THRBE_SEND_ALRT: R4088.1
~THRRSX_SENS_ALRT: R4089.1; also elsewhere on the board

Schematic: xdram.kicad_sch

Parts:
C1313, C1314, C1315, C1316, C1317, C1318, C1319, C1320, C1321, C1322, C1323, C1324, C1325, C1326, C1327, C1328, C1329, C1330, C1331, C1332, C1333, C1334, C1335, C1336, C1337, C1338, C1339, C1340, C1341, C1342, C1343, C1344, C1345, C1346, C1347, C1348, C1349, C1350, C1351, C1352, C1353, C1354, C1355, C1356, C1357, C1358, C1359, C1360, C1361, C1362, C1363, C1364, C1365, C1366, C1367, C1368, C1369, C1370: 0.1u 10V; C_0402_1005Metric
C1605, C1606, C1609, C1610: 1u 10V; C_0402_1005Metric
C1607, C1608, C1611, C1612: 10u 6.3V; C_0402_1005Metric
Q1201, Q1301: RK7002; SOT-23
Q1202, Q1302: SST2222AT; SOT-23
R1204, R1304: 10; R_0805_2012Metric
R1205, R1305: 22.1; R_0805_2012Metric
R1225, R1226, R1227, R1228, R1229, R1230, R1231, R1232, R1233, R1234, R1235, R1236, R1325, R1326, R1327, R1328, R1329, R1330, R1331, R1332, R1333, R1334, R1335, R1336: 43.2; R_0402_1005Metric
TP1202, TP1302: TestPoint; TestPoint_Pad_1.0x1.0mm
U1201: Y0_XDR0; FBGA-104_16x11_15.18x14.56mm
U1202: Y0_XDR1; FBGA-104_16x11_15.18x14.56mm
U1301: Y1_XDR0; FBGA-104_16x11_15.18x14.56mm
U1302: Y1_XDR1; FBGA-104_16x11_15.18x14.56mm

Connections:
+1.2V_YC_RC_VDDIO: C1315.1, C1318.1, C1321.1, C1324.1, C1327.1, C1330.1, C1333.1, C1336.1, C1339.1, C1342.1, C1345.1, C1348.1, C1351.1, C1354.1, C1357.1, C1360.1, C1363.1, C1366.1, C1369.1, C1370.1, C1606.1, C1608.1, C1610.1, C1612.1, U1201.B11 (Vterm), U1201.C5 (Vterm), U1201.C6 (Vterm), U1201.J5 (Vterm), U1201.J6 (Vterm), U1201.K11 (Vterm), U1202.B11 (Vterm), U1202.C5 (Vterm), U1202.C6 (Vterm), U1202.J5 (Vterm), U1202.J6 (Vterm), U1202.K11 (Vterm), U1301.B11 (Vterm), U1301.C5 (Vterm), U1301.C6 (Vterm), U1301.J5 (Vterm), U1301.J6 (Vterm), U1301.K11 (Vterm), U1302.B11 (Vterm), U1302.C5 (Vterm), U1302.C6 (Vterm), U1302.J5 (Vterm), U1302.J6 (Vterm), U1302.K11 (Vterm); also elsewhere on the board
+1.8V_VDD_MEM: C1313.1, C1314.1, C1316.1, C1317.1, C1319.1, C1320.1, C1322.1, C1323.1, C1325.1, C1326.1, C1328.1, C1329.1, C1331.1, C1332.1, C1334.1, C1335.1, C1337.1, C1338.1, C1340.1, C1341.1, C1343.1, C1344.1, C1346.1, C1347.1, C1349.1, C1350.1, C1352.1, C1353.1, C1355.1, C1356.1, C1358.1, C1359.1, C1361.1, C1362.1, C1364.1, C1365.1, C1367.1, C1368.1, C1605.1, C1607.1, C1609.1, C1611.1, U1201.A5 (Vdd), U1201.A12 (Vdd), U1201.B5 (Vdd), U1201.C13 (Vdd), U1201.D1 (Vdd), U1201.D6 (Vdd), U1201.D11 (Vdd), U1201.D16 (Vdd), U1201.E6 (Vdd), U1201.F5 (Vdd), U1201.F12 (Vdd), U1201.G1 (Vdd), U1201.G11 (Vdd), U1201.G16 (Vdd), U1201.H16 (Vdd), U1201.J1 (Vdd), U1201.J2 (Vdd), U1201.J3 (Vdd), U1201.J13 (Vdd), U1201.K5 (Vdd), U1201.L5 (Vdd), U1201.L12 (Vdd), U1202.A5 (Vdd), U1202.A12 (Vdd), U1202.B5 (Vdd), U1202.C13 (Vdd), U1202.D1 (Vdd), U1202.D6 (Vdd), U1202.D11 (Vdd), U1202.D16 (Vdd), U1202.E6 (Vdd), U1202.F5 (Vdd), U1202.F12 (Vdd), U1202.G1 (Vdd), U1202.G11 (Vdd), U1202.G16 (Vdd), U1202.H16 (Vdd), U1202.J1 (Vdd), U1202.J2 (Vdd), U1202.J3 (Vdd), U1202.J13 (Vdd), U1202.K5 (Vdd), U1202.L5 (Vdd), U1202.L12 (Vdd), U1301.A5 (Vdd), U1301.A12 (Vdd), U1301.B5 (Vdd), U1301.C13 (Vdd), U1301.D1 (Vdd), U1301.D6 (Vdd), U1301.D11 (Vdd), U1301.D16 (Vdd), U1301.E6 (Vdd), U1301.F5 (Vdd), U1301.F12 (Vdd), U1301.G1 (Vdd), U1301.G11 (Vdd), U1301.G16 (Vdd), U1301.H16 (Vdd), U1301.J1 (Vdd), U1301.J2 (Vdd), U1301.J3 (Vdd), U1301.J13 (Vdd), U1301.K5 (Vdd), U1301.L5 (Vdd), U1301.L12 (Vdd), U1302.A5 (Vdd), U1302.A12 (Vdd), U1302.B5 (Vdd), U1302.C13 (Vdd), U1302.D1 (Vdd), U1302.D6 (Vdd), U1302.D11 (Vdd), U1302.D16 (Vdd), U1302.E6 (Vdd), U1302.F5 (Vdd), U1302.F12 (Vdd), U1302.G1 (Vdd), U1302.G11 (Vdd), U1302.G16 (Vdd), U1302.H16 (Vdd), U1302.J1 (Vdd), U1302.J2 (Vdd), U1302.J3 (Vdd), U1302.J13 (Vdd), U1302.K5 (Vdd), U1302.L5 (Vdd), U1302.L12 (Vdd)
BE_RQ_SCK_BJT: Q1202.1 (B), Q1302.1 (B)
BE_Y0_RQ0: R1225.1, U1201.C3 (RQ0), U1202.C3 (RQ0); also elsewhere on the board
BE_Y0_RQ1: R1226.1, U1201.D13 (RQ1), U1202.D13 (RQ1); also elsewhere on the board
BE_Y0_RQ2: R1227.1, U1201.D14 (RQ2), U1202.D14 (RQ2); also elsewhere on the board
BE_Y0_RQ3: R1228.1, U1201.D4 (RQ3), U1202.D4 (RQ3); also elsewhere on the board
BE_Y0_RQ4: R1229.1, U1201.D3 (RQ4), U1202.D3 (RQ4); also elsewhere on the board
BE_Y0_RQ5: R1230.1, U1201.E14 (RQ5), U1202.E14 (RQ5); also elsewhere on the board
BE_Y0_RQ6: R1231.1, U1201.G14 (RQ6), U1202.G14 (RQ6); also elsewhere on the board
BE_Y0_RQ7: R1232.1, U1201.G13 (RQ7), U1202.G13 (RQ7); also elsewhere on the board
BE_Y0_RQ8: R1233.1, U1201.H14 (RQ8), U1202.H14 (RQ8); also elsewhere on the board
BE_Y0_RQ9: R1234.1, U1201.H13 (RQ9), U1202.H13 (RQ9); also elsewhere on the board
BE_Y0_RQ10: R1235.1, U1201.H3 (RQ10), U1202.H3 (RQ10); also elsewhere on the board
BE_Y0_RQ11: R1236.1, U1201.H4 (RQ11), U1202.H4 (RQ11); also elsewhere on the board
BE_Y0_RQ_CFM: U1201.G3 (CFM), U1202.G3 (CFM); also elsewhere on the board
BE_Y0_RQ_CFMN: U1201.G4 (CFMN), U1202.G4 (CFMN); also elsewhere on the board
BE_Y0_RQ_SCK: Q1202.3 (C); also elsewhere on the board
BE_Y1_RQ0: R1325.1, U1301.C3 (RQ0), U1302.C3 (RQ0); also elsewhere on the board
BE_Y1_RQ1: R1326.1, U1301.D13 (RQ1), U1302.D13 (RQ1); also elsewhere on the board
BE_Y1_RQ2: R1327.1, U1301.D14 (RQ2), U1302.D14 (RQ2); also elsewhere on the board
BE_Y1_RQ3: R1328.1, U1301.D4 (RQ3), U1302.D4 (RQ3); also elsewhere on the board
BE_Y1_RQ4: R1329.1, U1301.D3 (RQ4), U1302.D3 (RQ4); also elsewhere on the board
BE_Y1_RQ5: R1330.1, U1301.E14 (RQ5), U1302.E14 (RQ5); also elsewhere on the board
BE_Y1_RQ6: R1331.1, U1301.G14 (RQ6), U1302.G14 (RQ6); also elsewhere on the board
BE_Y1_RQ7: R1332.1, U1301.G13 (RQ7), U1302.G13 (RQ7); also elsewhere on the board
BE_Y1_RQ8: R1333.1, U1301.H14 (RQ8), U1302.H14 (RQ8); also elsewhere on the board
BE_Y1_RQ9: R1334.1, U1301.H13 (RQ9), U1302.H13 (RQ9)
BE_Y1_RQ10: R1335.1, U1301.H3 (RQ10), U1302.H3 (RQ10); also elsewhere on the board
BE_Y1_RQ11: R1336.1, U1301.H4 (RQ11), U1302.H4 (RQ11); also elsewhere on the board
BE_Y1_RQ_CFM: U1301.G3 (CFM), U1302.G3 (CFM)
BE_Y1_RQ_CFMN: U1301.G4 (CFMN), U1302.G4 (CFMN)
BE_Y1_RQ_SCK: Q1302.3 (C)
GND: C1313.2, C1314.2, C1315.2, C1316.2, C1317.2, C1318.2, C1319.2, C1320.2, C1321.2, C1322.2, C1323.2, C1324.2, C1325.2, C1326.2, C1327.2, C1328.2, C1329.2, C1330.2, C1331.2, C1332.2, C1333.2, C1334.2, C1335.2, C1336.2, C1337.2, C1338.2, C1339.2, C1340.2, C1341.2, C1342.2, C1343.2, C1344.2, C1345.2, C1346.2, C1347.2, C1348.2, C1349.2, C1350.2, C1351.2, C1352.2, C1353.2, C1354.2, C1355.2, C1356.2, C1357.2, C1358.2, C1359.2, C1360.2, C1361.2, C1362.2, C1363.2, C1364.2, C1365.2, C1366.2, C1367.2, C1368.2, C1369.2, C1370.2, C1605.2, C1606.2, C1607.2, C1608.2, C1609.2, C1610.2, C1611.2, C1612.2, Q1202.2 (E), Q1302.2 (E), U1201.A6 (GND), U1201.A11 (GND), U1201.B6 (GND), U1201.B12 (GND), U1201.C2 (GND), U1201.C4 (GND), U1201.C11 (GND), U1201.C12 (GND), U1201.C14 (GND), U1201.E1 (GND), U1201.E11 (GND), U1201.E16 (GND), U1201.F6 (GND), U1201.F11 (GND), U1201.G6 (GND), U1201.H1 (GND), U1201.H6 (GND), U1201.H11 (GND), U1201.J4 (GND), U1201.J11 (GND), U1201.J12 (GND), U1201.J16 (GND), U1201.K6 (GND), U1201.K12 (GND), U1201.L6 (GND), U1201.L11 (GND), U1202.A6 (GND), U1202.A11 (GND), U1202.B6 (GND), U1202.B12 (GND), U1202.C2 (GND), U1202.C4 (GND), U1202.C11 (GND), U1202.C12 (GND), U1202.C14 (GND), U1202.E1 (GND), U1202.E11 (GND), U1202.E16 (GND), U1202.F6 (GND), U1202.F11 (GND), U1202.G6 (GND), U1202.H1 (GND), U1202.H6 (GND), U1202.H11 (GND), U1202.J4 (GND), U1202.J11 (GND), U1202.J12 (GND), U1202.J16 (GND), U1202.K6 (GND), U1202.K12 (GND), U1202.L6 (GND), U1202.L11 (GND), U1301.A6 (GND), U1301.A11 (GND), U1301.B6 (GND), U1301.B12 (GND), U1301.C2 (GND), U1301.C4 (GND), U1301.C11 (GND), U1301.C12 (GND), U1301.C14 (GND), U1301.E1 (GND), U1301.E11 (GND), U1301.E16 (GND), U1301.F6 (GND), U1301.F11 (GND), U1301.G6 (GND), U1301.H1 (GND), U1301.H6 (GND), U1301.H11 (GND), U1301.J4 (GND), U1301.J11 (GND), U1301.J12 (GND), U1301.J16 (GND), U1301.K6 (GND), U1301.K12 (GND), U1301.L6 (GND), U1301.L11 (GND), U1302.A6 (GND), U1302.A11 (GND), U1302.B6 (GND), U1302.B12 (GND), U1302.C2 (GND), U1302.C4 (GND), U1302.C11 (GND), U1302.C12 (GND), U1302.C14 (GND), U1302.E1 (GND), U1302.E11 (GND), U1302.E16 (GND), U1302.F6 (GND), U1302.F11 (GND), U1302.G6 (GND), U1302.H1 (GND), U1302.H6 (GND), U1302.H11 (GND), U1302.J4 (GND), U1302.J11 (GND), U1302.J12 (GND), U1302.J16 (GND), U1302.K6 (GND), U1302.K12 (GND), U1302.L6 (GND), U1302.L11 (GND); also elsewhere on the board
unnamed: Q1201.3 (D), R1204.2, R1205.1
unnamed: Q1301.3 (D), R1304.2, R1305.1
unnamed: R1225.2, R1226.2, R1227.2, R1228.2, R1229.2, R1230.2, R1231.2, R1232.2, R1233.2, R1234.2, R1235.2, R1236.2
unnamed: R1325.2, R1326.2, R1327.2, R1328.2, R1329.2, R1330.2, R1331.2, R1332.2, R1333.2, R1334.2, R1335.2, R1336.2
XDR_RQ_VREF_FET: Q1201.2 (G), Q1301.2 (G); also elsewhere on the board
Y0_XDR0_DQ0: U1201.B16 (DQ0); also elsewhere on the board
Y0_XDR0_DQ1: U1201.K16 (DQ1); also elsewhere on the board
Y0_XDR0_DQ2: U1201.A2 (DQ2); also elsewhere on the board
Y0_XDR0_DQ3: U1201.L2 (DQ3); also elsewhere on the board
Y0_XDR0_DQ4: U1201.B4 (DQ4); also elsewhere on the board
Y0_XDR0_DQ5: U1201.K4 (DQ5); also elsewhere on the board
Y0_XDR0_DQ6: U1201.A14 (DQ6); also elsewhere on the board
Y0_XDR0_DQ7: U1201.L14 (DQ7)
Y0_XDR0_DQ8: U1201.B2 (DQ8); also elsewhere on the board
Y0_XDR0_DQ9: U1201.K2 (DQ9)
Y0_XDR0_DQ10: U1201.A16 (DQ10); also elsewhere on the board
Y0_XDR0_DQ11: U1201.L16 (DQ11); also elsewhere on the board
Y0_XDR0_DQ12: U1201.B14 (DQ12); also elsewhere on the board
Y0_XDR0_DQ13: U1201.K14 (DQ13)
Y0_XDR0_DQ14: U1201.A4 (DQ14); also elsewhere on the board
Y0_XDR0_DQ15: U1201.L4 (DQ15)
Y0_XDR0_DQN0: U1201.B15 (DQN0); also elsewhere on the board
Y0_XDR0_DQN1: U1201.K15 (DQN1); also elsewhere on the board
Y0_XDR0_DQN2: U1201.A1 (DQN2); also elsewhere on the board
Y0_XDR0_DQN3: U1201.L1 (DQN3); also elsewhere on the board
Y0_XDR0_DQN4: U1201.B3 (DQN4); also elsewhere on the board
Y0_XDR0_DQN5: U1201.K3 (DQN5); also elsewhere on the board
Y0_XDR0_DQN6: U1201.A13 (DQN6); also elsewhere on the board
Y0_XDR0_DQN7: U1201.L13 (DQN7)
Y0_XDR0_DQN8: U1201.B1 (DQN8); also elsewhere on the board
Y0_XDR0_DQN9: U1201.K1 (DQN9)
Y0_XDR0_DQN10: U1201.A15 (DQN10); also elsewhere on the board
Y0_XDR0_DQN11: U1201.L15 (DQN11); also elsewhere on the board
Y0_XDR0_DQN12: U1201.B13 (DQN12); also elsewhere on the board
Y0_XDR0_DQN13: U1201.K13 (DQN13)
Y0_XDR0_DQN14: U1201.A3 (DQN14); also elsewhere on the board
Y0_XDR0_DQN15: U1201.L3 (DQN15)
Y0_XDR1_DQ0: U1202.B16 (DQ0); also elsewhere on the board
Y0_XDR1_DQ1: U1202.K16 (DQ1); also elsewhere on the board
Y0_XDR1_DQ2: U1202.A2 (DQ2); also elsewhere on the board
Y0_XDR1_DQ3: U1202.L2 (DQ3); also elsewhere on the board
Y0_XDR1_DQ4: U1202.B4 (DQ4); also elsewhere on the board
Y0_XDR1_DQ5: U1202.K4 (DQ5); also elsewhere on the board
Y0_XDR1_DQ6: U1202.A14 (DQ6); also elsewhere on the board
Y0_XDR1_DQ7: U1202.L14 (DQ7); also elsewhere on the board
Y0_XDR1_DQ8: U1202.B2 (DQ8); also elsewhere on the board
Y0_XDR1_DQ9: U1202.K2 (DQ9); also elsewhere on the board
Y0_XDR1_DQ10: U1202.A16 (DQ10); also elsewhere on the board
Y0_XDR1_DQ11: U1202.L16 (DQ11); also elsewhere on the board
Y0_XDR1_DQ12: U1202.B14 (DQ12); also elsewhere on the board
Y0_XDR1_DQ13: U1202.K14 (DQ13); also elsewhere on the board
Y0_XDR1_DQ14: U1202.A4 (DQ14); also elsewhere on the board
Y0_XDR1_DQ15: U1202.L4 (DQ15); also elsewhere on the board
Y0_XDR1_DQN0: U1202.B15 (DQN0); also elsewhere on the board
Y0_XDR1_DQN1: U1202.K15 (DQN1); also elsewhere on the board
Y0_XDR1_DQN2: U1202.A1 (DQN2); also elsewhere on the board
Y0_XDR1_DQN3: U1202.L1 (DQN3); also elsewhere on the board
Y0_XDR1_DQN4: U1202.B3 (DQN4); also elsewhere on the board
Y0_XDR1_DQN5: U1202.K3 (DQN5); also elsewhere on the board
Y0_XDR1_DQN6: U1202.A13 (DQN6); also elsewhere on the board
Y0_XDR1_DQN7: U1202.L13 (DQN7); also elsewhere on the board
Y0_XDR1_DQN8: U1202.B1 (DQN8); also elsewhere on the board
Y0_XDR1_DQN9: U1202.K1 (DQN9); also elsewhere on the board
Y0_XDR1_DQN10: U1202.A15 (DQN10); also elsewhere on the board
Y0_XDR1_DQN11: U1202.L15 (DQN11); also elsewhere on the board
Y0_XDR1_DQN12: U1202.B13 (DQN12); also elsewhere on the board
Y0_XDR1_DQN13: U1202.K13 (DQN13); also elsewhere on the board
Y0_XDR1_DQN14: U1202.A3 (DQN14); also elsewhere on the board
Y0_XDR1_DQN15: U1202.L3 (DQN15); also elsewhere on the board
Y0_XDR_RQ_VREF: Q1201.1 (S), TP1202.1 (1_1)
Y1_XDR0_DQ0: U1301.B16 (DQ0); also elsewhere on the board
Y1_XDR0_DQ1: U1301.K16 (DQ1); also elsewhere on the board
Y1_XDR0_DQ2: U1301.A2 (DQ2); also elsewhere on the board
Y1_XDR0_DQ3: U1301.L2 (DQ3); also elsewhere on the board
Y1_XDR0_DQ4: U1301.B4 (DQ4); also elsewhere on the board
Y1_XDR0_DQ5: U1301.K4 (DQ5); also elsewhere on the board
Y1_XDR0_DQ6: U1301.A14 (DQ6); also elsewhere on the board
Y1_XDR0_DQ7: U1301.L14 (DQ7); also elsewhere on the board
Y1_XDR0_DQ8: U1301.B2 (DQ8); also elsewhere on the board
Y1_XDR0_DQ9: U1301.K2 (DQ9); also elsewhere on the board
Y1_XDR0_DQ10: U1301.A16 (DQ10); also elsewhere on the board
Y1_XDR0_DQ11: U1301.L16 (DQ11); also elsewhere on the board
Y1_XDR0_DQ12: U1301.B14 (DQ12); also elsewhere on the board
Y1_XDR0_DQ13: U1301.K14 (DQ13); also elsewhere on the board
Y1_XDR0_DQ14: U1301.A4 (DQ14); also elsewhere on the board
Y1_XDR0_DQ15: U1301.L4 (DQ15); also elsewhere on the board
Y1_XDR0_DQN0: U1301.B15 (DQN0); also elsewhere on the board
Y1_XDR0_DQN1: U1301.K15 (DQN1); also elsewhere on the board
Y1_XDR0_DQN2: U1301.A1 (DQN2); also elsewhere on the board
Y1_XDR0_DQN3: U1301.L1 (DQN3); also elsewhere on the board
Y1_XDR0_DQN4: U1301.B3 (DQN4); also elsewhere on the board
Y1_XDR0_DQN5: U1301.K3 (DQN5); also elsewhere on the board
Y1_XDR0_DQN6: U1301.A13 (DQN6); also elsewhere on the board
Y1_XDR0_DQN7: U1301.L13 (DQN7); also elsewhere on the board
Y1_XDR0_DQN8: U1301.B1 (DQN8); also elsewhere on the board
Y1_XDR0_DQN9: U1301.K1 (DQN9); also elsewhere on the board
Y1_XDR0_DQN10: U1301.A15 (DQN10); also elsewhere on the board
Y1_XDR0_DQN11: U1301.L15 (DQN11); also elsewhere on the board
Y1_XDR0_DQN12: U1301.B13 (DQN12); also elsewhere on the board
Y1_XDR0_DQN13: U1301.K13 (DQN13); also elsewhere on the board
Y1_XDR0_DQN14: U1301.A3 (DQN14); also elsewhere on the board
Y1_XDR0_DQN15: U1301.L3 (DQN15); also elsewhere on the board
Y1_XDR1_DQ0: U1302.B16 (DQ0); also elsewhere on the board
Y1_XDR1_DQ1: U1302.K16 (DQ1)
Y1_XDR1_DQ2: U1302.A2 (DQ2); also elsewhere on the board
Y1_XDR1_DQ3: U1302.L2 (DQ3); also elsewhere on the board
Y1_XDR1_DQ4: U1302.B4 (DQ4); also elsewhere on the board
Y1_XDR1_DQ5: U1302.K4 (DQ5)
Y1_XDR1_DQ6: U1302.A14 (DQ6); also elsewhere on the board
Y1_XDR1_DQ7: U1302.L14 (DQ7); also elsewhere on the board
Y1_XDR1_DQ8: U1302.B2 (DQ8); also elsewhere on the board
Y1_XDR1_DQ9: U1302.K2 (DQ9)
Y1_XDR1_DQ10: U1302.A16 (DQ10); also elsewhere on the board
Y1_XDR1_DQ11: U1302.L16 (DQ11); also elsewhere on the board
Y1_XDR1_DQ12: U1302.B14 (DQ12); also elsewhere on the board
Y1_XDR1_DQ13: U1302.K14 (DQ13)
Y1_XDR1_DQ14: U1302.A4 (DQ14); also elsewhere on the board
Y1_XDR1_DQ15: U1302.L4 (DQ15)
Y1_XDR1_DQN0: U1302.B15 (DQN0); also elsewhere on the board
Y1_XDR1_DQN1: U1302.K15 (DQN1); also elsewhere on the board
Y1_XDR1_DQN2: U1302.A1 (DQN2); also elsewhere on the board
Y1_XDR1_DQN3: U1302.L1 (DQN3); also elsewhere on the board
Y1_XDR1_DQN4: U1302.B3 (DQN4); also elsewhere on the board
Y1_XDR1_DQN5: U1302.K3 (DQN5); also elsewhere on the board
Y1_XDR1_DQN6: U1302.A13 (DQN6); also elsewhere on the board
Y1_XDR1_DQN7: U1302.L13 (DQN7); also elsewhere on the board
Y1_XDR1_DQN8: U1302.B1 (DQN8); also elsewhere on the board
Y1_XDR1_DQN9: U1302.K1 (DQN9); also elsewhere on the board
Y1_XDR1_DQN10: U1302.A15 (DQN10); also elsewhere on the board
Y1_XDR1_DQN11: U1302.L15 (DQN11); also elsewhere on the board
Y1_XDR1_DQN12: U1302.B13 (DQN12); also elsewhere on the board
Y1_XDR1_DQN13: U1302.K13 (DQN13); also elsewhere on the board
Y1_XDR1_DQN14: U1302.A3 (DQN14); also elsewhere on the board
Y1_XDR1_DQN15: U1302.L3 (DQN15)
Y1_XDR_RQ_VREF: Q1301.1 (S), TP1302.1 (1_1)

Notes on the sheet:
Y1 XDR0 DECAP

Schematic: ethernet.kicad_sch

Parts:
C3502, C3503: 0.1u; C_0402_1005Metric
C3543, C3584: 15p 50V; C_0402_1005Metric
C3560: 0.1u 10V; C_0402_1005Metric
C3567, C3570, C3573, C3576: 0.01u; C_0402_1005Metric
D351, D352, D353, D354, D355, D356, D357, D358: ESD5Zxx; D_SOD-923
J3501: RJ45
L3501, L3502, L3503, L3504: L_Iron_Coupled_Small_1243; L_CommonModeChoke_Coilcraft_0805USB
Q3501: UMH2NTN; SOT-363_SC-70-6
Q3502: DTC144E; SOT-323_SC-70
Q3503: SI3493; TSOP-6_1.65x3.05mm_P0.95mm
Q3504: Si3460DV; TSOP-6_1.65x3.05mm_P0.95mm
R3505, R3506, R3507, R3508, R3509, R3510, R3511, R3512, R3513, R3514, R3515: 33; R_0402_1005Metric
R3520: 2200; R_0402_1005Metric
R3521, R3522: 1500; R_0402_1005Metric
R3523: 22; R_0402_1005Metric
R3524, R3525, R3526, R3527, R3528, R3529, R3530, R3531, R3532: 47; R_0402_1005Metric
R3536: 100k; R_0402_1005Metric
R3537: 150k; R_0402_1005Metric
R3538: XX; R_0402_1005Metric; not fitted
R3561: 220; R_0402_1005Metric
R3570, R3573, R3576, R3579, R3582, R3585, R3588, R3591: 49.9; R_0402_1005Metric
R3593: 0; R_0402_1005Metric
TP3501, TP3502: TestPoint; TestPoint_Pad_1.0x1.0mm
U3501: BD3520FVM-TR; MSOP-8_2.9x4mm_P0.65mm
U3502: MM1761KHBE; HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.4x3.2mm
U3503: 88E6108; LQFP-144_20x20mm_P0.5mm
Y3501: 25MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+3.3V_ESW: Q3503.1 (D), Q3503.2 (D), Q3503.5 (D), Q3503.6 (D)
+3.3V_EVER: R3521.2, R3522.2; also elsewhere on the board
+3.3V_MISC: Q3503.4 (S), R3536.2; also elsewhere on the board
GND: C3543.1, C3560.2, C3567.2, C3570.2, C3573.2, C3576.2, C3584.1, D351.2 (A), D352.2 (A), D353.2 (A), D354.2 (A), D355.2 (A), D356.2 (A), D357.2 (A), D358.2 (A), J3501.6, J3501.MP (MountPin), Q3501.1 (E1), Q3501.4 (E2), Q3502.2 (E), U3502.3 (GND), U3502.4 (GND), U3502.6 (GND), U3502.7 (GND), U3502.9 (GND), U3503.39 (P7_VDDAH), U3503.42 (VSS), U3503.45 (P6_VDDAH), U3503.48 (VDD_CORE), U3503.51 (P5_VDDAH), U3503.54 (VSS), U3503.107 (VSS), U3503.109 (VSS), U3503.121 (VSS), U3503.122 (P1_MDIN3), U3503.123 (P1_MDIP3), U3503.125 (P1_MDIN2), U3503.126 (P1_MDIP2), U3503.127 (P1_MDIN1), U3503.128 (P1_MDIP1), U3503.131 (P1_MDIN0), U3503.132 (P1_MDIP0), U3503.133 (VSS), U3503.134 (P0_MDIN3), U3503.135 (P0_MDIP3), U3503.137 (P0_MDIN2), U3503.138 (P0_MDIP2), U3503.139 (P0_MDIN1), U3503.140 (P0_MDIP1), U3503.143 (P0_MDIN0), U3503.144 (P0_MDIP0), Y3501.2, Y3501.4; also elsewhere on the board
unnamed: C3567.1, R3570.1, R3573.1
unnamed: C3570.1, R3576.1, R3579.1
unnamed: C3573.1, R3582.1, R3585.1
unnamed: C3576.1, R3588.1, R3591.1
unnamed: C3584.2, R3593.2, Y3501.1
unnamed: D351.1 (K), J3501.3, L3501.2
unnamed: D352.1 (K), J3501.2, L3501.3
unnamed: D353.1 (K), J3501.5, L3502.2
unnamed: D354.1 (K), J3501.4, L3502.3
unnamed: D355.1 (K), J3501.8, L3503.2
unnamed: D356.1 (K), J3501.7, L3503.3
unnamed: D357.1 (K), J3501.10, L3504.2
unnamed: D358.1 (K), J3501.9, L3504.3
unnamed: Q3501.2 (B1), Q3501.3 (C2), R3521.1
unnamed: Q3501.6 (C1), Q3502.1 (B), R3522.1, R3538.2, U3501.3 (EN), U3502.5 (EN)
unnamed: Q3501.5 (B2), R3520.2
unnamed: Q3502.3 (C), R3536.1, R3537.1
unnamed: Q3503.3 (G), R3537.2
unnamed: Q3504.1 (D), Q3504.2 (D), Q3504.5 (D), Q3504.6 (D)
unnamed: Q3504.3 (G), U3501.7 (G)
unnamed: R3561.1, U3503.28 (P2_LED2)
unnamed: L3501.1, R3573.2, U3503.119 (P2_MDIN0)
unnamed: L3502.1, R3579.2, U3503.115 (P2_MDIN1)
unnamed: L3503.1, R3585.2, U3503.113 (P2_MDIN2)
unnamed: L3504.1, R3591.2, U3503.110 (P2_MDIN3)
unnamed: L3501.4, R3570.2, U3503.120 (P2_MDIP0)
unnamed: L3502.4, R3576.2, U3503.116 (P2_MDIP1)
unnamed: L3503.4, R3582.2, U3503.114 (P2_MDIP2)
unnamed: L3504.4, R3588.2, U3503.111 (P2_MDIP3)
unnamed: R3523.2, U3503.62 (P3_CLK125n)
unnamed: R3515.2, U3503.90 (P3_RXCLK)
unnamed: R3514.2, U3503.89 (P3_RXD0)
unnamed: R3513.2, U3503.88 (P3_RXD1)
unnamed: R3512.2, U3503.87 (P3_RXD2)
unnamed: R3511.2, U3503.85 (P3_RXD3)
unnamed: R3510.2, U3503.83 (P3_RXD4)
unnamed: R3509.2, U3503.82 (P3_RXD5)
unnamed: R3508.2, U3503.81 (P3_RXD6)
unnamed: R3507.2, U3503.80 (P3_RXD7)
unnamed: R3505.2, U3503.77 (P3_RXDV)
unnamed: R3506.2, U3503.79 (P3_RXER)
unnamed: R3532.2, U3503.73 (P3_TXD0/ADDR0)
unnamed: R3531.2, U3503.72 (P3_TXD1/ADDR1)
unnamed: R3530.2, U3503.71 (P3_TXD2/ADDR2)
unnamed: R3529.2, U3503.70 (P3_TXD3/ADDR3)
unnamed: R3528.2, U3503.68 (P3_TXD4/ADDR4)
unnamed: R3527.2, U3503.67 (P3_TXD5/MODE0)
unnamed: R3526.2, U3503.65 (P3_TXD6/MODE1)
unnamed: R3525.2, U3503.64 (P3_TXD7/MODE2)
unnamed: R3524.2, U3503.63 (P3_TXEN/HALFDPX)
unnamed: C3502.2, U3503.55 (P4_RXN)
unnamed: C3503.2, U3503.56 (P4_RXP)
unnamed: C3543.2, U3503.7 (XTAL_IN), Y3501.3
unnamed: R3593.1, U3503.8 (XTAL_OUT)
P2_LED2: C3560.1, J3501.13, R3561.2
SB_GBE_ETOMOD: TP3502.1 (1_1); also elsewhere on the board
SB_GBE_GMIICLK: R3515.1; also elsewhere on the board
SB_GBE_RXD0: R3532.1; also elsewhere on the board
SB_GBE_RXD1: R3531.1; also elsewhere on the board
SB_GBE_RXD2: R3530.1; also elsewhere on the board
SB_GBE_RXD3: R3529.1; also elsewhere on the board
SB_GBE_RXD4: R3528.1; also elsewhere on the board
SB_GBE_RXD5: R3527.1; also elsewhere on the board
SB_GBE_RXD6: R3526.1; also elsewhere on the board
SB_GBE_RXD7: R3525.1; also elsewhere on the board
SB_GBE_TXCLK: TP3501.1 (1_1); also elsewhere on the board
SB_GBE_TXD0: R3514.1; also elsewhere on the board
SB_GBE_TXD1: R3513.1; also elsewhere on the board
SB_GBE_TXD2: R3512.1; also elsewhere on the board
SB_GBE_TXD3: R3511.1; also elsewhere on the board
SB_GBE_TXD4: R3510.1; also elsewhere on the board
SB_GBE_TXD5: R3509.1; also elsewhere on the board
SB_GBE_TXD6: R3508.1; also elsewhere on the board
SB_GBE_TXD7: R3507.1; also elsewhere on the board
SB_GBE_TXEN: R3505.1; also elsewhere on the board
SB_GBE_TXER: R3506.1; also elsewhere on the board
SW_4_A: R3520.1, R3538.1; also elsewhere on the board
WLAN_RXN: C3502.1; also elsewhere on the board
WLAN_RXP: C3503.1; also elsewhere on the board
WLAN_TXN: U3503.58 (P4_TXN); also elsewhere on the board
WLAN_TXP: U3503.59 (P4_TXP); also elsewhere on the board

# Repository stonedDiscord/ps3 (continued)

## KiCad design cok-001/cok-001.kicad_pcb (continued)

Schematic: eegs.kicad_sch

Parts:
C7286: 10V; C_0402_1005Metric; not fitted
JL7001, JL7003, JL7004, JL7005, JL7006: TestPoint; TestPoint_Pad_1.0x1.0mm
R7010, R7012, R7073, R7074: XX; R_0402_1005Metric; not fitted
R7029, R7030, R7034: 47; R_0402_1005Metric
R7031, R7032, R7033, R7041, R7042: 0; R_0603_1608Metric
R7035: XX; R_0603_1608Metric; not fitted
R7036, R7037: 4700; R_0402_1005Metric
R7038: 22; R_0402_1005Metric
R7044, R7045: 1k; R_0402_1005Metric
R7080: 56; R_0402_1005Metric
RN7001, RN7002, RN7003, RN7004, RN7005, RN7006: R_Pack08; R_Cat16-8
RN7007, RN7008, RN7009, RN7010, RN7011, RN7012: 22; R_Array_Convex_4x0402
RN7013, RN7014, RN7015, RN7016, RN7017, RN7018, RN7019, RN7020, RN7023: 56; R_Array_Convex_4x0402
RN7021: 4700; R_Array_Convex_4x0402
TP7004, TP7005, TP7006, TP7007, TP7008, TP7009: TestPoint; TestPoint_Pad_1.0x1.0mm
U7001: ICS626BGLFT; TSSOP-24_4.4x7.8mm_P0.65mm
U7002, U7003: BGA-54_7x9_11.8x12.0mm
U7004: EEGS
U7005: LM75B; VSSOP-8_3x3mm_P0.65mm; not fitted
Y7001: XX; Crystal_SMD_FOX_FE-2Pin_7.5x5.0mm; not fitted

Connections:
+1.8V_EEGS_VDDIO: RN7001.9 (R8.2), RN7001.10 (R7.2), RN7001.11 (R6.2), RN7001.12 (R5.2), RN7001.13 (R4.2), RN7001.14 (R3.2), RN7001.15 (R2.2), RN7001.16 (R1.2), RN7002.9 (R8.2), RN7002.10 (R7.2), RN7002.11 (R6.2), RN7002.12 (R5.2), RN7002.13 (R4.2), RN7002.14 (R3.2), RN7002.15 (R2.2), RN7002.16 (R1.2), RN7003.9 (R8.2), RN7003.10 (R7.2), RN7003.11 (R6.2), RN7003.12 (R5.2), RN7003.13 (R4.2), RN7003.14 (R3.2), RN7003.15 (R2.2), RN7003.16 (R1.2), RN7004.9 (R8.2), RN7004.10 (R7.2), RN7004.11 (R6.2), RN7004.12 (R5.2), RN7004.13 (R4.2), RN7004.14 (R3.2), RN7004.15 (R2.2), RN7004.16 (R1.2), RN7005.9 (R8.2), RN7005.10 (R7.2), RN7005.11 (R6.2), RN7005.12 (R5.2), RN7005.13 (R4.2), RN7005.14 (R3.2), RN7005.15 (R2.2), RN7005.16 (R1.2), RN7006.9 (R8.2), RN7006.10 (R7.2), RN7006.11 (R6.2), RN7006.12 (R5.2), RN7006.13 (R4.2), RN7006.14 (R3.2), RN7006.15 (R2.2), RN7006.16 (R1.2); also elsewhere on the board
+3.3V_THERMAL: C7286.1, U7005.6 (A1), U7005.8 (+Vs); also elsewhere on the board
/PS2 EEGS/CFMN_A: U7002.D7 (CFMN), U7004.G32 (CFMNA)
/PS2 EEGS/CFMN_B: U7003.D7 (CFMN), U7004.AA30 (CFMNB)
/PS2 EEGS/CFM_A: U7002.C7 (CFM), U7004.G30 (CFMA)
/PS2 EEGS/CFM_B: U7003.C7 (CFM), U7004.AA32 (CFMB)
/PS2 EEGS/CTMN_A: U7002.E1 (CTM), U7004.H30 (CTMNA)
/PS2 EEGS/CTMN_B: U7003.D1 (CTMN), U7004.AB32 (CTMNB)
/PS2 EEGS/CTM_A: U7002.D1 (CTMN), U7004.H32 (CTMA)
/PS2 EEGS/CTM_B: U7003.E1 (CTM), U7004.AB30 (CTMB)
/PS2 EEGS/DQA_A0: RN7002.4 (R4.1), U7002.C1 (DQA0), U7004.F32 (DQAA0)
/PS2 EEGS/DQA_A1: RN7002.2 (R2.1), U7002.C2 (DQA1), U7004.F30 (DQAA1)
/PS2 EEGS/DQA_A2: RN7002.1 (R1.1), U7002.C6 (DQA2), U7004.E32 (DQAA2)
/PS2 EEGS/DQA_A3: RN7002.6 (R6.1), U7002.B1 (DQA3), U7004.E30 (DQAA3)
/PS2 EEGS/DQA_A4: RN7002.5 (R5.1), U7002.B7 (DQA4), U7004.D32 (DQAA4)
/PS2 EEGS/DQA_A5: RN7002.3 (R3.1), U7002.B6 (DQA5), U7004.D30 (DQAA5)
/PS2 EEGS/DQA_A6: RN7002.8 (R8.1), U7002.B2 (DQA6), U7004.C32 (DQAA6)
/PS2 EEGS/DQA_A7: RN7002.7 (R7.1), U7002.A7 (DQA7), U7004.C30 (DQAA7)
/PS2 EEGS/DQA_B0: RN7005.4 (R4.1), U7003.C1 (DQA0), U7004.Y30 (DQAB0)
/PS2 EEGS/DQA_B1: RN7005.2 (R2.1), U7003.C2 (DQA1), U7004.Y32 (DQAB1)
/PS2 EEGS/DQA_B2: RN7005.1 (R1.1), U7003.C6 (DQA2), U7004.W30 (DQAB2)
/PS2 EEGS/DQA_B3: RN7005.6 (R6.1), U7003.B1 (DQA3), U7004.W32 (DQAB3)
/PS2 EEGS/DQA_B4: RN7005.3 (R3.1), U7003.B7 (DQA4), U7004.V30 (DQAB4)
/PS2 EEGS/DQA_B5: RN7005.5 (R5.1), U7003.B6 (DQA5), U7004.V32 (DQAB5)
/PS2 EEGS/DQA_B6: RN7005.8 (R8.1), U7003.B2 (DQA6), U7004.U30 (DQAB6)
/PS2 EEGS/DQA_B7: RN7005.7 (R7.1), U7003.A7 (DQA7), U7004.U32 (DQAB7)
/PS2 EEGS/DQB_A0: RN7003.7 (R7.1), U7002.G7 (DQB0), U7004.N30 (DQBA0)
/PS2 EEGS/DQB_A1: RN7001.1 (R1.1), U7002.G6 (DQB1), U7004.N32 (DQBA1)
/PS2 EEGS/DQB_A2: RN7003.6 (R6.1), U7002.G2 (DQB2), U7004.P30 (DQBA2)
/PS2 EEGS/DQB_A3: RN7003.4 (R4.1), U7002.H1 (DQB3), U7004.P32 (DQBA3)
/PS2 EEGS/DQB_A4: RN7003.3 (R3.1), U7002.H7 (DQB4), U7004.R30 (DQBA4)
/PS2 EEGS/DQB_A5: RN7003.5 (R5.1), U7002.H6 (DQB5), U7004.R32 (DQBA5)
/PS2 EEGS/DQB_A6: RN7003.2 (R2.1), U7002.H2 (DQB6), U7004.T30 (DQBA6)
/PS2 EEGS/DQB_A7: RN7003.1 (R1.1), U7002.J7 (DQB7), U7004.T32 (DQBA7)
/PS2 EEGS/DQB_B0: RN7004.1 (R1.1), U7003.G7 (DQB0), U7004.AG32 (DQBB0)
/PS2 EEGS/DQB_B1: RN7006.7 (R7.1), U7003.G6 (DQB1), U7004.AG30 (DQBB1)
/PS2 EEGS/DQB_B2: RN7006.6 (R6.1), U7003.G2 (DQB2), U7004.AH32 (DQBB2)
/PS2 EEGS/DQB_B3: RN7006.5 (R5.1), U7003.H1 (DQB3), U7004.AH30 (DQBB3)
/PS2 EEGS/DQB_B4: RN7006.4 (R4.1), U7003.H7 (DQB4), U7004.AJ32 (DQBB4)
/PS2 EEGS/DQB_B5: RN7006.3 (R3.1), U7003.H6 (DQB5), U7004.AJ30 (DQBB5)
/PS2 EEGS/DQB_B6: RN7006.2 (R2.1), U7003.H2 (DQB6), U7004.AK32 (DQBB6)
/PS2 EEGS/DQB_B7: RN7006.1 (R1.1), U7003.J7 (DQB7), U7004.AK30 (DQBB7)
/PS2 EEGS/RQ_A0: RN7003.8 (R8.1), U7002.G1 (RQ0), U7004.M32 (RQA0)
/PS2 EEGS/RQ_A1: RN7001.2 (R2.1), U7002.F2 (RQ1), U7004.M30 (RQA1)
/PS2 EEGS/RQ_A2: RN7001.5 (R5.1), U7002.F6 (RQ2), U7004.L32 (RQA2)
/PS2 EEGS/RQ_A3: RN7001.3 (R3.1), U7002.F7 (RQ3), U7004.L30 (RQA3)
/PS2 EEGS/RQ_A4: RN7001.4 (R4.1), U7002.F1 (RQ4), U7004.K32 (RQA4)
/PS2 EEGS/RQ_A5: RN7001.8 (R8.1), U7002.E7 (RQ5), U7004.K30 (RQA5)
/PS2 EEGS/RQ_A6: RN7001.7 (R7.1), U7002.E6 (RQ6), U7004.J32 (RQA6)
/PS2 EEGS/RQ_A7: RN7001.6 (R6.1), U7002.E2 (RQ7), U7004.J30 (RQA7)
/PS2 EEGS/RQ_B0: RN7006.8 (R8.1), U7003.G1 (RQ0), U7004.AF30 (RQB0)
/PS2 EEGS/RQ_B1: RN7004.4 (R4.1), U7003.F2 (RQ1), U7004.AF32 (RQB1)
/PS2 EEGS/RQ_B2: RN7004.5 (R5.1), U7003.F6 (RQ2), U7004.AE30 (RQB2)
/PS2 EEGS/RQ_B3: RN7004.3 (R3.1), U7003.F7 (RQ3), U7004.AE32 (RQB3)
/PS2 EEGS/RQ_B4: RN7004.2 (R2.1), U7003.F1 (RQ4), U7004.AD30 (RQB4)
/PS2 EEGS/RQ_B5: RN7004.8 (R8.1), U7003.E7 (RQ5), U7004.AD32 (RQB5)
/PS2 EEGS/RQ_B6: RN7004.7 (R7.1), U7003.E6 (RQ6), U7004.AC30 (RQB6)
/PS2 EEGS/RQ_B7: RN7004.6 (R6.1), U7003.E2 (RQ7), U7004.AC32 (RQB7)
DRCG_GEN18M: R7012.1, U7001.4 (Xin), Y7001.1; also elsewhere on the board
GND: C7286.2, JL7005.1 (1_1), R7031.1, R7032.1, R7033.1, R7041.2, R7042.2, RN7021.5 (R4.2), RN7021.6 (R3.2), U7001.2 (VSSRP), U7001.6 (VSSVPA), U7001.8 (VSS54), U7001.13 (VSSVP), U7001.15 (VSSL), U7001.19 (VSSR), U7001.22 (VSSR), U7002.A1 (NC), U7002.A6 (GND), U7002.B3 (GND), U7002.C5 (GND), U7002.D3 (GND), U7002.D5 (GNDA), U7002.E3 (GND), U7002.F5 (GND), U7002.G3 (GND), U7002.H3 (GND), U7002.J6 (GND), U7003.A1 (NC), U7003.A6 (GND), U7003.B3 (GND), U7003.C5 (GND), U7003.D3 (GND), U7003.D5 (GNDA), U7003.E3 (GND), U7003.F5 (GND), U7003.G3 (GND), U7003.H3 (GND), U7003.J6 (GND), U7004.A2 (GND), U7004.A30 (GNDr), U7004.AA5 (GND), U7004.AA28 (GNDr), U7004.AA29 (GNDr), U7004.AA31 (GNDr), U7004.AB29 (GNDr), U7004.AB31 (GNDr), U7004.AC29 (GNDr), U7004.AC31 (GNDr), U7004.AD5 (GND), U7004.AD29 (GNDr), U7004.AD31 (GNDr), U7004.AE29 (GNDr), U7004.AE31 (GNDr), U7004.AF5 (GND), U7004.AF28 (GNDr), U7004.AF29 (GNDr), U7004.AF31 (GNDr), U7004.AG4 (GND), U7004.AG28 (GNDr), U7004.AG29 (GNDr), U7004.AG31 (GNDr), U7004.AH4 (GND), U7004.AH5 (GND), U7004.AH7 (GND), U7004.AH10 (GND), U7004.AH12 (GND), U7004.AH15 (GND), U7004.AH16 (GND), U7004.AH18 (GND), U7004.AH20 (GND), U7004.AH21 (GND), U7004.AH26 (GND), U7004.AH29 (GNDr), U7004.AH31 (GNDr), U7004.AJ5 (GND), U7004.AJ13 (GND), U7004.AJ18 (GND), U7004.AJ26 (GND), U7004.AJ27 (GND), U7004.AJ29 (GNDr), U7004.AJ31 (GNDr), U7004.AK2 (GND), U7004.AK3 (GND), U7004.AK5 (GND), U7004.AK8 (GND), U7004.AK17 (GND), U7004.AK22 (GND), U7004.AK27 (GND), U7004.AK29 (GND), U7004.AK31 (GNDr), U7004.AL2 (GND), U7004.AL3 (GND), U7004.AL17 (GND), U7004.AL29 (GND), U7004.AL30 (GNDr), U7004.AL32 (GNDr), U7004.AM30 (GND), U7004.B3 (GND), U7004.B17 (GND), U7004.B29 (GND), U7004.B30 (GNDr), U7004.B32 (GNDr), U7004.C3 (GND), U7004.C4 (GND), U7004.C5 (GND), U7004.C8 (GND), U7004.C20 (GND), U7004.C23 (GND), U7004.C29 (GND), U7004.C31 (GNDr), U7004.D6 (GND), U7004.D8 (GND), U7004.D9 (GND), U7004.D11 (GND), U7004.D14 (GND), U7004.D16 (GND), U7004.D19 (GND), U7004.D21 (GND), U7004.D23 (GND), U7004.D24 (GND), U7004.D27 (GND), U7004.D31 (GNDr), U7004.E4 (GND), U7004.E6 (GND), U7004.E9 (GND), U7004.E11 (GND), U7004.E12 (GND), U7004.E14 (GND), U7004.E16 (GND), U7004.E17 (GND), U7004.E19 (GND), U7004.E21 (GND), U7004.E24 (GND), U7004.E27 (GND), U7004.E29 (GNDr), U7004.E31 (GNDr), U7004.F5 (GND), U7004.F28 (GNDr), U7004.F29 (GNDr), U7004.F31 (GNDr), U7004.G3 (GND), U7004.G4 (GND), U7004.G28 (GNDr), U7004.G29 (GNDr), U7004.G31 (GNDr), U7004.H29 (GNDr), U7004.H31 (GNDr), U7004.J5 (GND), U7004.J28 (GNDr), U7004.J29 (GNDr), U7004.J31 (GNDr), U7004.K4 (GND), U7004.K5 (GND), U7004.K29 (GNDr), U7004.K31 (GNDr), U7004.L3 (GND), U7004.L4 (GND), U7004.L29 (GNDr), U7004.L31 (GNDr), U7004.M29 (GNDr), U7004.M31 (GNDr), U7004.N4 (GND), U7004.N5 (GND), U7004.N29 (GNDr), U7004.N31 (GNDr), U7004.P4 (GND), U7004.P29 (GNDr), U7004.P31 (GNDr), U7004.R5 (GND), U7004.R29 (GNDr), U7004.R31 (GNDr), U7004.T3 (GND), U7004.T4 (GND), U7004.T29 (DQBA8), U7004.T31 (GNDr), U7004.U4 (GND), U7004.U5 (GND), U7004.U31 (GNDr), U7004.V29 (GNDr), U7004.V31 (GNDr), U7004.W1 (EEenable), U7004.W2 (GSenable), U7004.W5 (GND), U7004.W29 (GNDr), U7004.W31 (GNDr), U7004.Y29 (GNDr), U7004.Y31 (GNDr), U7005.4 (GND), U7005.5 (A2), U7005.7 (A0); also elsewhere on the board
unnamed: R7010.1, Y7001.2
unnamed: R7035.2, R7036.2, R7037.2
unnamed: RN7007.8 (R1.2), U7004.AK24 (RO3)
unnamed: RN7007.7 (R2.2), U7004.AM25 (RO2)
unnamed: RN7007.6 (R3.2), U7004.AL25 (RO1)
unnamed: RN7007.5 (R4.2), U7004.AM26 (RO0)
unnamed: RN7008.8 (R1.2), U7004.AL21 (GO3)
unnamed: RN7008.7 (R2.2), U7004.AK21 (GO2)
unnamed: RN7008.6 (R3.2), U7004.AM22 (GO1)
unnamed: RN7008.5 (R4.2), U7004.AL22 (GO0)
unnamed: RN7009.8 (R1.2), U7004.AK15 (BO3)
unnamed: RN7009.7 (R2.2), U7004.AM16 (BO2)
unnamed: RN7009.6 (R3.2), U7004.AM17 (BO1)
unnamed: RN7009.5 (R4.2), U7004.AM18 (B00)
unnamed: RN7010.8 (R1.2), U7004.AM23 (RO7)
unnamed: RN7010.7 (R2.2), U7004.AL23 (RO6)
unnamed: RN7010.6 (R3.2), U7004.AM24 (RO5)
unnamed: RN7010.5 (R4.2), U7004.AL24 (RO4)
unnamed: RN7011.8 (R1.2), U7004.AL18 (GO7)
unnamed: RN7011.7 (R2.2), U7004.AK18 (GO6)
unnamed: RN7011.6 (R3.2), U7004.AM19 (GO5)
unnamed: RN7011.5 (R4.2), U7004.AL19 (GO4)
unnamed: RN7012.8 (R1.2), U7004.AL14 (BO7)
unnamed: RN7012.7 (R2.2), U7004.AK14 (BO6)
unnamed: RN7012.6 (R3.2), U7004.AM15 (BO5)
unnamed: RN7012.5 (R4.2), U7004.AL15 (BO4)
unnamed: RN7013.1 (R1.1), U7004.B20 (AD2)
unnamed: RN7013.2 (R2.1), U7004.A20 (AD1)
unnamed: RN7013.3 (R3.1), U7004.B19 (AD0)
unnamed: RN7013.4 (R4.1), U7004.C19 (AD3)
unnamed: RN7014.1 (R1.1), U7004.A13 (AD17)
unnamed: RN7014.2 (R2.1), U7004.B13 (AD19)
unnamed: RN7014.3 (R3.1), U7004.C13 (AD22)
unnamed: RN7014.4 (R4.1), U7004.A14 (AD16)
unnamed: RN7015.1 (R1.1), U7004.C14 (AD13)
unnamed: RN7015.2 (R2.1), U7004.B14 (AD14)
unnamed: RN7015.3 (R3.1), U7004.B15 (AD15)
unnamed: RN7015.4 (R4.1), U7004.C15 (AD11)
unnamed: RN7016.1 (R1.1), U7004.C10 (AD27)
unnamed: RN7016.2 (R2.1), U7004.B10 (AD25)
unnamed: RN7016.3 (R3.1), U7004.A10 (AD23)
unnamed: RN7016.4 (R4.1), U7004.B11 (AD24)
unnamed: RN7017.1 (R1.1), U7004.A18 (AD6)
unnamed: RN7017.2 (R2.1), U7004.B18 (AD9)
unnamed: RN7017.3 (R3.1), U7004.C18 (AD7)
unnamed: RN7017.4 (R4.1), U7004.A19 (AD4)
unnamed: RN7018.1 (R1.1), U7004.B12 (AD28)
unnamed: RN7018.2 (R2.1), U7004.A12 (AD18)
unnamed: RN7018.3 (R3.1), U7004.A11 (AD20)
unnamed: RN7018.4 (R4.1), U7004.C11 (AD21)
unnamed: RN7019.1 (R1.1), U7004.A17 (AD5)
unnamed: RN7019.2 (R2.1), U7004.B16 (AD10)
unnamed: RN7019.3 (R3.1), U7004.A16 (AD8)
unnamed: RN7019.4 (R4.1), U7004.A15 (AD12)
unnamed: RN7020.1 (R1.1), U7004.C9 (AD30)
unnamed: RN7020.2 (R2.1), U7004.B9 (AD29)
unnamed: RN7020.3 (R3.1), U7004.A9 (AD26)
unnamed: RN7020.4 (R4.1), U7004.A8 (AD31)
unnamed: RN7021.1 (R1.1), U7004.B25 (TestClock)
unnamed: RN7021.2 (R2.1), U7004.C25 (TestReset)
unnamed: RN7021.3 (R3.1), U7004.B27 (CMD)
unnamed: R7038.2, RN7021.4 (R4.1)
unnamed: RN7023.1 (R1.1), U7004.C21 (~INTOUT)
unnamed: RN7023.2 (R2.1), U7004.B23 (~WRAC)
unnamed: RN7023.3 (R3.1), U7004.B24 (DREQ0)
unnamed: RN7023.4 (R4.1), U7004.A25 (DACK)
unnamed: R7010.2, R7012.2, U7001.3 (Xout)
unnamed: U7002.A2 (VCMOS), U7002.J2 (VCMOS)
unnamed: U7002.B5 (VDD), U7002.C3 (VDD), U7002.D6 (VDDA), U7002.E5 (VDD), U7002.F3 (VDD), U7002.G5 (VDD), U7002.H5 (VDD)
unnamed: U7003.A2 (VCMOS), U7003.J2 (VCMOS)
unnamed: U7003.B5 (VDD), U7003.C3 (VDD), U7003.D6 (VDDA), U7003.E5 (VDD), U7003.F3 (VDD), U7003.G5 (VDD), U7003.H5 (VDD)
unnamed: U7004.AA4 (AVD1), U7004.AF3 (AVD1), U7004.AH23 (AVD0), U7004.AH24 (AVD0), U7004.AH25 (AVD0), U7004.AJ7 (AVD1), U7004.AJ9 (AVD1), U7004.AJ10 (AVD1), U7004.AJ12 (AVD1), U7004.AJ23 (AVD0), U7004.V4 (AVD1), U7004.Y4 (AVD1)
unnamed: U7004.AD4 (AVDA1), U7004.AJ8 (AVDA1), U7004.AJ11 (AVDA1), U7004.AJ19 (AVDA0), U7004.AJ20 (AVDA0), U7004.AJ21 (AVDA0), U7004.W4 (AVDA1)
unnamed: R7033.2, U7004.AA1 (CLKGCCG)
unnamed: TP7005.1 (1_1), U7004.AK19 (CLKMON)
unnamed: R7080.1, U7004.A24 (DREQ1)
unnamed: TP7004.1 (1_1), U7004.AK26 (FLDO)
unnamed: R7042.1, U7004.W3 (GearRatio)
unnamed: R7036.1, U7004.U2 (JTCK)
unnamed: R7031.2, U7004.T2 (JTDI)
unnamed: R7035.1, U7004.V1 (JTDO)
unnamed: R7037.1, U7004.U1 (JTMS)
unnamed: R7032.2, U7004.U3 (JTRST)
unnamed: TP7007.1 (1_1), U7004.AM12 (PCLK2)
unnamed: TP7006.1 (1_1), U7004.AM27 (PCLK)
unnamed: R7045.1, U7004.Y1 (PwrUp)
unnamed: TP7008.1 (1_1), U7004.AM29 (ROOut)
unnamed: R7038.1, U7004.A27 (SCK)
unnamed: JL7001.1 (1_1), U7004.C1 (SRXD)
unnamed: JL7006.1 (1_1), U7004.F3 (STXD)
unnamed: TP7009.1 (1_1), U7004.C27 (SynClk)
unnamed: R7030.2, U7004.A4 (TIMIN0)
unnamed: R7029.2, U7004.B5 (TIMIN1)
unnamed: R7041.1, U7004.A6 (TestClkSw)
unnamed: U7004.AA3 (VDD), U7004.AC4 (VDD), U7004.AC5 (VDD), U7004.AF4 (VDD), U7004.AH6 (VDD), U7004.AH9 (VDD), U7004.AH13 (VDD), U7004.AH19 (VDD), U7004.AH22 (VDD), U7004.AJ3 (VDD), U7004.AJ6 (VDD), U7004.AJ22 (VDD), U7004.AK12 (VDD), U7004.AK16 (VDD), U7004.AK25 (VDD), U7004.AK28 (VDD), U7004.AL16 (VDD), U7004.AM2 (VDD), U7004.B1 (VDD), U7004.C16 (VDD), U7004.D3 (VDD), U7004.D4 (VDD), U7004.D7 (VDD), U7004.D10 (VDD), U7004.D13 (VDD), U7004.D18 (VDD), U7004.D22 (VDD), U7004.D25 (VDD), U7004.E7 (VDD), U7004.E10 (VDD), U7004.E13 (VDD), U7004.E18 (VDD), U7004.E22 (VDD), U7004.E25 (VDD), U7004.F4 (VDD), U7004.H4 (VDD), U7004.H5 (VDD), U7004.L5 (VDD), U7004.P5 (VDD), U7004.T5 (VDD), U7004.V5 (VDD)
unnamed: U7004.AD28 (VDDar), U7004.M28 (VDDar)
unnamed: U7004.A31 (VDDio), U7004.AE28 (VDDio), U7004.AM31 (VDDio), U7004.D29 (VDDio), U7004.P28 (VDDio), U7004.V28 (VDDio)
unnamed: U7004.AB4 (VDDo), U7004.AB5 (VDDo), U7004.AE4 (VDDo), U7004.AE5 (VDDo), U7004.AG5 (VDDo), U7004.AH8 (VDDo), U7004.AH11 (VDDo), U7004.AH14 (VDDo), U7004.AH17 (VDDo), U7004.AH27 (VDDo), U7004.AJ4 (VDDo), U7004.AJ14 (VDDo), U7004.AJ28 (VDDo), U7004.AK4 (VDDo), U7004.AK20 (VDDo), U7004.AK23 (VDDo), U7004.AL1 (VDDo), U7004.B2 (VDDo), U7004.C2 (VDDo), U7004.C12 (VDDo), U7004.C17 (VDDo), U7004.C28 (VDDo), U7004.D5 (VDDo), U7004.D12 (VDDo), U7004.D15 (VDDo), U7004.D17 (VDDo), U7004.D20 (VDDo), U7004.D28 (VDDo), U7004.E5 (VDDo), U7004.E8 (VDDo), U7004.E15 (VDDo), U7004.E20 (VDDo), U7004.E23 (VDDo), U7004.G5 (VDDo), U7004.J4 (VDDo), U7004.M4 (VDDo), U7004.M5 (VDDo), U7004.R4 (VDDo), U7004.Y5 (VDDo)
unnamed: U7004.AC28 (VDDr), U7004.AH28 (VDDr), U7004.E28 (VDDr), U7004.L28 (VDDr), U7004.N28 (VDDr), U7004.R28 (VDDr), U7004.T28 (VDDr), U7004.U28 (VDDr), U7004.W28 (VDDr)
unnamed: R7044.1, U7004.B4 (~ERESET)
unnamed: R7034.2, U7004.A5 (~INTIN1)
unnamed: R7034.1, U7004.AL11 (~INT)
unnamed: JL7003.1 (1_1), U7004.D2 (~SCTS)
unnamed: JL7004.1 (1_1), U7004.D1 (~SRTS)
unnamed: R7074.2, U7005.2 (SCL)
unnamed: R7073.2, U7005.1 (SDA)
PWRUP_EE: R7045.2; also elsewhere on the board
RSX_VI12: RN7009.4 (R4.1); also elsewhere on the board
RSX_VI13: RN7009.3 (R3.1)
RSX_VI14: RN7009.2 (R2.1); also elsewhere on the board
RSX_VI15: RN7009.1 (R1.1); also elsewhere on the board
RSX_VI16: RN7012.4 (R4.1); also elsewhere on the board
RSX_VI17: RN7012.3 (R3.1); also elsewhere on the board
RSX_VI18: RN7012.2 (R2.1); also elsewhere on the board
RSX_VI19: RN7012.1 (R1.1); also elsewhere on the board
RSX_VI20: RN7008.4 (R4.1); also elsewhere on the board
RSX_VI21: RN7008.3 (R3.1); also elsewhere on the board
RSX_VI22: RN7008.2 (R2.1); also elsewhere on the board
RSX_VI23: RN7008.1 (R1.1); also elsewhere on the board
RSX_VI24: RN7011.4 (R4.1); also elsewhere on the board
RSX_VI25: RN7011.3 (R3.1); also elsewhere on the board
RSX_VI26: RN7011.2 (R2.1); also elsewhere on the board
RSX_VI27: RN7011.1 (R1.1); also elsewhere on the board
RSX_VI28: RN7007.4 (R4.1); also elsewhere on the board
RSX_VI29: RN7007.3 (R3.1); also elsewhere on the board
RSX_VI30: RN7007.2 (R2.1); also elsewhere on the board
RSX_VI31: RN7007.1 (R1.1); also elsewhere on the board
RSX_VI32: RN7010.4 (R4.1); also elsewhere on the board
RSX_VI33: RN7010.3 (R3.1); also elsewhere on the board
RSX_VI34: RN7010.2 (R2.1); also elsewhere on the board
RSX_VI35: RN7010.1 (R1.1); also elsewhere on the board
SIF_AD0: RN7013.6 (R3.2); also elsewhere on the board
SIF_AD1: RN7013.7 (R2.2); also elsewhere on the board
SIF_AD2: RN7013.8 (R1.2); also elsewhere on the board
SIF_AD3: RN7013.5 (R4.2); also elsewhere on the board
SIF_AD4: RN7017.5 (R4.2); also elsewhere on the board
SIF_AD5: RN7019.8 (R1.2); also elsewhere on the board
SIF_AD6: RN7017.8 (R1.2); also elsewhere on the board
SIF_AD7: RN7017.6 (R3.2); also elsewhere on the board
SIF_AD8: RN7019.6 (R3.2); also elsewhere on the board
SIF_AD9: RN7017.7 (R2.2); also elsewhere on the board
SIF_AD10: RN7019.7 (R2.2); also elsewhere on the board
SIF_AD11: RN7015.5 (R4.2); also elsewhere on the board
SIF_AD12: RN7019.5 (R4.2); also elsewhere on the board
SIF_AD13: RN7015.8 (R1.2); also elsewhere on the board
SIF_AD14: RN7015.7 (R2.2); also elsewhere on the board
SIF_AD15: RN7015.6 (R3.2); also elsewhere on the board
SIF_AD16: RN7014.5 (R4.2); also elsewhere on the board
SIF_AD17: RN7014.8 (R1.2); also elsewhere on the board
SIF_AD18: RN7018.7 (R2.2); also elsewhere on the board
SIF_AD19: RN7014.7 (R2.2); also elsewhere on the board
SIF_AD20: RN7018.6 (R3.2); also elsewhere on the board
SIF_AD21: RN7018.5 (R4.2); also elsewhere on the board
SIF_AD22: RN7014.6 (R3.2); also elsewhere on the board
SIF_AD23: RN7016.6 (R3.2); also elsewhere on the board
SIF_AD24: RN7016.5 (R4.2); also elsewhere on the board
SIF_AD25: RN7016.7 (R2.2); also elsewhere on the board
SIF_AD26: RN7020.6 (R3.2); also elsewhere on the board
SIF_AD27: RN7016.8 (R1.2); also elsewhere on the board
SIF_AD28: RN7018.8 (R1.2); also elsewhere on the board
SIF_AD29: RN7020.7 (R2.2); also elsewhere on the board
SIF_AD30: RN7020.8 (R1.2); also elsewhere on the board
SIF_AD31: RN7020.5 (R4.2); also elsewhere on the board
SIF_DACK: RN7023.5 (R4.2); also elsewhere on the board
SIF_DREQ0: RN7023.6 (R3.2); also elsewhere on the board
SIF_DREQ1: R7080.2
THR_I2C_SCL: R7074.1; also elsewhere on the board
THR_I2C_SDA: R7073.1; also elsewhere on the board
~EGRST: R7044.2; also elsewhere on the board
~SIF_WRAC: RN7023.7 (R2.2); also elsewhere on the board
~SINT: RN7023.8 (R1.2); also elsewhere on the board

Schematic: usb.kicad_sch

Parts:
C3301, C3309, C3311, C3313, C3314, C3316, C3328: 0.1u; C_0402_1005Metric
C3324, C3325: 220u 10V; CP_EIA-6032-28_Kemet-C
D3301, D3302, D3303, D3304, D3305: XX; D_0603_1608Metric; not fitted
D3316, D3317, D3318, D3319, D3320, D3321, D3322, D3323: EDZCTE616; D_SOD-923
J3301, J3302: USB_A_Stacked; USB_A_Vertical
L3301, L3302, L3303, L3304: 0uH; L_CommonModeChoke_Coilcraft_0805USB
R3303: 1k; R_0402_1005Metric
R3306, R3307, R3308, R3309, R3310: XX; R_0402_1005Metric; not fitted
R3328, R3329, R3350: 0; R_0603_1608Metric
R3342, R3345, R3360, R3361, R3362, R3363, R3364, R3365, R3366, R3367: 0; R_0402_1005Metric
R3343, R3346: XX; R_0402_1005Metric
R3356, R3357, R3358, R3359: 10k; R_0402_1005Metric
TH3302: Thermistor
TP9505, TP9506, TP9507, TP9508, TP9509, TP9510, TP9511, TP9512, TP9520, TP9522, TP9527, TP9529: TestPoint; TestPoint_Pad_1.0x1.0mm
U3302: BU9869W; SSOP-8_2.95x2.8mm_P0.65mm
U3303, U3304: BD6517F; SSOP-8_3.9x5.05mm_P1.27mm
U3305: LQFP-64_10x10mm_P0.5mm
Y3301: 12MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
GND: C3301.1, C3309.1, C3311.1, C3313.2, C3314.2, C3316.2, C3324.2, C3325.2, C3328.1, D3316.2 (A), D3317.2 (A), D3318.2 (A), D3319.2 (A), D3320.2 (A), D3321.2 (A), D3322.2 (A), D3323.2 (A), J3301.4 (GND1), J3301.8 (GND2), J3301.9 (Shield), J3302.4 (GND1), J3302.8 (GND2), J3302.9 (Shield), R3306.1, R3307.1, R3308.1, R3309.1, R3310.1, U3302.5 (GND), U3303.6 (GND), U3304.6 (GND), U3305.1 (AGND), U3305.12 (ANGD), U3305.19 (AGND), U3305.23 (AGND), U3305.29 (AGND), U3305.36 (DGND), U3305.46 (DGND), U3305.51 (DGND), U3305.58 (DGND), U3305.62 (DGND); also elsewhere on the board
H4_OVC1: R3356.1
H4_OVC2: R3357.1
H4_OVC3: R3358.1
H4_OVC4: R3359.1
H4_PWREN1: R3343.1, R3346.1
H4_PWREN2: R3345.1
H4_PWREN4: R3342.1
unnamed: D3301.2 (A), U3305.34 (GREEN4)
unnamed: D3301.1 (K), R3306.2
unnamed: D3302.2 (A), U3305.44 (GREEN3)
unnamed: D3302.1 (K), R3307.2
unnamed: D3303.2 (A), U3302.4 (DO), U3305.48 (GREEN2/EE_DO)
unnamed: D3303.1 (K), R3308.2
unnamed: D3304.2 (A), U3302.1 (CS), U3305.61 (AMBER1/EE_CS)
unnamed: D3304.1 (K), R3309.2
unnamed: D3305.2 (A), U3305.53 (PGANG/SUSPND)
unnamed: D3305.1 (K), R3310.2
unnamed: D3316.1 (K), J3301.7 (D2+), L3304.1, TP9505.1 (1_1)
unnamed: D3317.1 (K), J3301.6 (D2-), L3304.4, TP9506.1 (1_1)
unnamed: D3318.1 (K), J3301.3 (D1+), L3303.1, TP9507.1 (1_1)
unnamed: D3319.1 (K), J3301.2 (D1-), L3303.4, TP9508.1 (1_1)
unnamed: D3320.1 (K), J3302.7 (D2+), L3302.1, TP9509.1 (1_1)
unnamed: D3321.1 (K), J3302.6 (D2-), L3302.4, TP9510.1 (1_1)
unnamed: D3322.1 (K), J3302.2 (D1-), L3301.4, TP9512.1 (1_1)
unnamed: D3323.1 (K), J3302.3 (D1+), L3301.1, TP9511.1 (1_1)
unnamed: C3324.1, J3301.1 (VBUS1), TP9520.1 (1_1), U3303.5 (OUTB)
unnamed: C3325.1, J3301.5 (VBUS2), TP9527.1 (1_1), U3303.8 (OUTA)
unnamed: J3302.1 (VBUS1), TP9522.1 (1_1), U3304.5 (OUTB)
unnamed: J3302.5 (VBUS2), TP9529.1 (1_1), U3304.8 (OUTA)
unnamed: L3301.2, R3366.1
unnamed: L3301.3, R3367.1
unnamed: L3302.2, R3364.1
unnamed: L3302.3, R3365.1
unnamed: L3303.2, R3363.2
unnamed: L3303.3, R3362.2
unnamed: L3304.2, R3361.2
unnamed: L3304.3, R3360.2
unnamed: R3303.1, Y3301.1
unnamed: R3350.2, TH3302.2
unnamed: U3302.3 (DI), U3305.49 (AMBER2/EE_DI)
unnamed: U3302.2 (SCLK), U3305.60 (GREEN1/EE_SK)
unnamed: C3301.2, C3309.2, C3311.2, C3313.1, C3328.2, U3302.8 (VCC), U3305.37 (DVDD), U3305.47 (DVDD), U3305.52 (DVDD), U3305.59 (DVDD), U3305.63 (DVDD)
unnamed: R3345.2, R3346.2, U3303.1 (CTRLA)
unnamed: R3356.2, U3303.2 (FLAGA)
unnamed: R3357.2, U3303.3 (FLAGB)
unnamed: C3314.1, U3303.7 (VDD)
unnamed: R3342.2, R3343.2, U3304.4 (CTRLB)
unnamed: R3358.2, U3304.2 (FLAGA)
unnamed: R3359.2, U3304.3 (FLAGB)
unnamed: C3316.1, R3350.1, U3304.7 (VDD)
unnamed: R3328.1, U3305.3 (DM0)
unnamed: R3360.1, U3305.8 (DM1)
unnamed: R3362.1, U3305.14 (DM2)
unnamed: R3365.2, U3305.25 (DM3)
unnamed: R3367.2, U3305.31 (DM4)
unnamed: R3329.1, U3305.4 (DP0)
unnamed: R3361.1, U3305.9 (DP1)
unnamed: R3363.1, U3305.15 (DP2)
unnamed: R3364.2, U3305.26 (DP3)
unnamed: R3366.2, U3305.32 (DP4)
unnamed: U3305.20 (X1), Y3301.3
unnamed: R3303.2, U3305.21 (X2)
SB_USB1_DM: R3328.2; also elsewhere on the board
SB_USB1_DP: R3329.2; also elsewhere on the board

Schematic: wireless.kicad_sch

Parts:
D3701: CL-197HG5-CD-T; D_0603_1608Metric
J3701: Conn_01x33_MountingPin; Molex_502244-3330_1x33-1MP_P0.5mm_Horizontal
L3701, L3702, L3703: XX; L_CommonModeChoke_Coilcraft_0805USB; not fitted
Q3701: UMH2NTN; SOT-363_SC-70-6
R3701: 0; R_0805_2012Metric
R3704, R3705, R3710, R3711, R3712, R3714, R3715, R3716, R3726: 0; R_0402_1005Metric
R3723: 680; R_0402_1005Metric
R3724: XX; R_0402_1005Metric; not fitted
R3725: 4700; R_0402_1005Metric
TH3701, TH3702: Thermistor_PTC

Connections:
+5V_EVER: R3701.1; also elsewhere on the board
+5V_MISC: R3723.1, R3724.1, TH3702.1; also elsewhere on the board
BT_WAKE: J3701.30
GND: J3701.2, J3701.6, J3701.7, J3701.8, J3701.11, J3701.14, J3701.15, J3701.18, J3701.19, J3701.22, J3701.32, J3701.MP (MountPin), Q3701.1 (E1), Q3701.4 (E2); also elsewhere on the board
MDC_AP: R3711.1
MDIO_AP: R3712.1
unnamed: D3701.2 (A), R3723.2
unnamed: D3701.1 (K), Q3701.3 (C2)
unnamed: J3701.1, TH3701.2
unnamed: J3701.3, J3701.4, J3701.5, TH3702.2
unnamed: J3701.12, L3701.3, L3701.4, R3704.2
unnamed: J3701.13, L3701.1, L3701.2, R3705.2
unnamed: J3701.23, R3710.2
unnamed: J3701.24, R3711.2
unnamed: J3701.25, R3712.2
unnamed: J3701.27, R3714.2
unnamed: J3701.28, R3715.2
unnamed: J3701.29, R3716.2
unnamed: J3701.31, R3726.2
unnamed: J3701.33, Q3701.2 (B1)
unnamed: Q3701.5 (B2), Q3701.6 (C1), R3725.2
unnamed: R3701.2, TH3701.1
unnamed: R3724.2, R3725.1, R3726.1
SB_USB3_DN: J3701.21, L3703.1, L3703.2
SB_USB3_DP: J3701.20, L3703.3, L3703.4; also elsewhere on the board
SB_USB3_POWEN: R3710.1
SW_4_A: J3701.9; also elsewhere on the board
WLAN_RXN: J3701.17, L3702.1, L3702.2; also elsewhere on the board
WLAN_RXP: J3701.16, L3702.3, L3702.4; also elsewhere on the board
WLAN_TXN: R3705.1; also elsewhere on the board
WLAN_TXP: R3704.1; also elsewhere on the board
~11G_RESET: R3716.1; also elsewhere on the board
~BT_RESET: J3701.10; also elsewhere on the board
~ESW_INT: R3714.1
~ESW_RST: R3715.1

Schematic: powermgmt.kicad_sch

Parts:
C6002, C6039: 1u 16V; C_0603_1608Metric
C6004, C6058, C6077, C6087: XX; C_0402_1005Metric; not fitted
C6009: 50V; C_0402_1005Metric; not fitted
C6010: 22u 16V; C_1210_3225Metric
C6011: 680p; C_0402_1005Metric
C6021, C6023, C6025: 0.1u 16V; C_0603_1608Metric
C6022: 0.001u 50V; C_0402_1005Metric
C6024: 0.1u 16V; C_0402_1005Metric
C6027, C6068: 4.7u 10V; C_0805_2012Metric
C6029: 330u; CP_EIA-6032-20_AVX-F
C6032, C6084, C6093: 0.022u 16V; C_0402_1005Metric
C6036, C6037: 16V; C_0402_1005Metric; not fitted
C6041: 25V; C_1210_3225Metric; not fitted
C6050, C6056, C6075, C6080, C6082, C6091: 2.2u 10V; C_0805_2012Metric
C6055, C6085: XX 25V; C_0402_1005Metric; not fitted
C6057, C6078: 1u 10V; C_0402_1005Metric
C6061, C6062, C6063, C6073, C6076: 0.1u 10V; C_0402_1005Metric
C6067, C6089: 10u 6.3V; C_0805_2012Metric
C6079: XX 16V; C_0402_1005Metric; not fitted
C6088: 470p; C_0402_1005Metric
C6090, C6096, C6500: 100p; C_0402_1005Metric
C6095: 220u 2.5V; CP_EIA-3528-21_Kemet-B
F6001: 5A; Fuse_1206_3216Metric
FB6001: 0uH; L_0603_1608Metric
J6004: +12V_MAIN; Banana_Jack_2Pin
J6005: +5V_EVER; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
L6001: 2uH; L_TDK_SLF6028
L6002: 1uH; L_TDK_SLF6028
L6003, L6004: 5.6uH; L_TDK_SLF10145
PS6001: 2A; Fuse_1210_3225Metric
Q6001, Q6002: FDQ7238AS; SO-14_3.9x8.65mm_P1.27mm
Q6003: DTC144E; SOT-323_SC-70
Q6004, Q6007, Q6008: SI3493; TSOP-6_1.65x3.05mm_P0.95mm
Q6006, Q6009: UMH2NTN; SOT-363_SC-70-6
Q6010: SI4943; SOIC-8_3.9x4.9mm_P1.27mm
Q6012: Si3460DV; TSOP-6_1.65x3.05mm_P0.95mm
R6001: 3600; R_0402_1005Metric
R6002: 2700; R_0402_1005Metric
R6018: 200k; R_0402_1005Metric
R6019: 0; R_0402_1005Metric
R6020: 360k; R_0402_1005Metric
R6022: 47k; R_0402_1005Metric
R6029, R6030: 10; R_0402_1005Metric
R6031, R6039, R6043, R6069: XX; R_0402_1005Metric; not fitted
R6032: 10k; R_0603_1608Metric
R6033: 1500; R_0402_1005Metric
R6034: 2400; R_0402_1005Metric
R6045, R6079, R6083: 100k; R_0402_1005Metric
R6047, R6060, R6061: 100k; R_0603_1608Metric
R6063, R6064: 150k; R_0603_1608Metric
R6068: 120; R_0402_1005Metric
R6081, R6085: 150k; R_0402_1005Metric
R6084: 220; R_0402_1005Metric
R6098: 390; R_0402_1005Metric
R6100: 82; R_0402_1005Metric
R6523: 390; R_0603_1608Metric
R6524, R6525: 1k; R_0402_1005Metric
TH6001: Fuse; Fuse_1210_3225Metric
TH6002: Fuse; Fuse_2920_7451Metric
TP6048, TP6053, TP6060, TP6063, TP9656: TestPoint; TestPoint_Pad_1.0x1.0mm
TP6056: TestPoint; TestPoint_Pad_D1.0mm
TP9623: TestPoint; TestPoint_Pad_D1.5mm
U6003: MB39A; TSSOP-30_4.4x7.8mm_P0.5mm
U6004, U6023: PST3642UL; SC-82AB
U6005, U6009: NCP511SN33T1G; SOT-23-5
U6006, U6008, U6019: NCP511SN18T1; SOT-23-5
U6007: TPS73101DBV; SOT-23-5
U6011: NCP511; TSOP-5_1.65x3.05mm_P0.95mm
U6012: MM3141; TSOP-5_1.65x3.05mm_P0.95mm
U6013: MM1562; SSOP-8_3.9x5.05mm_P1.27mm
U6014, U6021: MM1591; SSOP-8_3.9x5.05mm_P1.27mm
U6017: BD3521; MSOP-8_2.9x4mm_P0.65mm
U6020: MM1593DFBEG; SSOP-8_3.9x5.05mm_P1.27mm
U6022: MM1593; SSOP-8_3.9x5.05mm_P1.27mm

Connections:
+1.2V_MC2_VDDIO: C6068.1, R6069.2, TP6063.1 (1_1), U6012.5 (Vout); also elsewhere on the board
+1.5V_AVCG_VDDIO: C6091.1, R6100.2, TP6056.1 (1_1), U6019.5 (OUT); also elsewhere on the board
+1.5V_BRIDGE: U6021.1 (Vout)
+1.5V_RSX_VDDIO: C6093.1, C6095.1, Q6012.4 (S), TP9656.1 (1_1), U6017.5 (VFB), U6017.6 (VS); also elsewhere on the board
+1.6V_BE_VDDA: U6007.5 (OUT); also elsewhere on the board
+1.7V_MISC: C6075.1, Q6012.1 (D), Q6012.2 (D), Q6012.5 (D), Q6012.6 (D), U6017.8 (VD); also elsewhere on the board
+1.8V_RSX_PLL_VDD: C6057.1, C6061.1, C6062.1, C6063.1, C6073.1, FB6001.2
+1.8V_SB_PERI: U6014.1 (Vout)
+2.5V_LREG_XCG_500_MEM: U6013.1 (Vout)
+2.5V_SB_PLL_VDDC: C6067.1, R6068.2, TP6060.1 (1_1), U6011.5 (Vout)
+3.3V_BRIDGE: U6022.1 (Vout); also elsewhere on the board
+3.3V_EVER: R6032.2; also elsewhere on the board
+3.3V_MISC: C6029.1, C6050.1, C6082.1, L6004.2, Q6004.4 (S), R6047.2, U6007.1 (IN), U6008.1 (IN), U6011.1 (Vin), U6012.1 (Vin), U6013.8 (Vin), U6014.8 (Vin), U6019.1 (IN), U6021.8 (Vin); also elsewhere on the board
+3.3V_MK_VDD: C6089.1, R6098.2, TP6053.1 (1_1), U6020.1 (Vout)
+3.3V_SB_VDDIO: Q6004.1 (D), Q6004.2 (D), Q6004.5 (D), Q6004.6 (D), R6523.2; also elsewhere on the board
+5V_BD: Q6010.5 (D2), Q6010.6 (D2), R6043.2
+5V_EVER: C6022.1, J6005.1, J6005.2, U6004.2 (VDD), U6005.1 (IN), U6006.1 (IN), U6009.1 (IN); also elsewhere on the board
+5V_HDD: Q6007.1 (D), Q6007.2 (D), Q6007.5 (D), Q6007.6 (D), R6524.2; also elsewhere on the board
+5V_MISC: C6078.1, C6080.1, U6017.4 (VCC), U6020.8 (Vin), U6022.8 (Vin); also elsewhere on the board
+5V_USB: Q6008.1 (D), Q6008.2 (D), Q6008.5 (D), Q6008.6 (D), R6525.2
+12V_BD: Q6010.7 (D1), Q6010.8 (D1), R6039.2
+12V_MAIN: F6001.1, J6004.1, PS6001.1, R6001.2; also elsewhere on the board
ACDC_STBY: J6005.5, TP9623.1 (1_1); also elsewhere on the board
GND: C6010.2, C6021.2, C6022.2, C6023.2, C6027.2, C6029.2, C6032.2, C6039.2, C6041.2, C6050.2, C6055.2, C6056.2, C6057.2, C6058.2, C6061.2, C6062.2, C6063.2, C6067.2, C6068.2, C6073.2, C6075.2, C6076.1, C6077.2, C6078.2, C6079.2, C6080.2, C6082.2, C6084.2, C6085.2, C6087.2, C6088.2, C6089.2, C6090.2, C6091.2, C6093.2, C6095.2, C6096.2, C6500.2, J6004.2, J6005.3, J6005.4, Q6001.5 (D), Q6001.6, Q6001.7, Q6002.5 (D), Q6002.6, Q6002.7, Q6003.2 (E), Q6006.1 (E1), Q6006.4 (E2), Q6009.1 (E1), Q6009.4 (E2), R6039.1, R6043.1, R6068.1, R6069.1, R6098.1, R6100.1, R6523.1, R6524.1, R6525.1, U6003.7 (SGND), U6003.20 (PGND2), U6003.26 (PGND), U6004.1 (GND), U6005.2 (GND), U6006.2 (GND), U6007.2 (GND), U6008.2 (GND), U6009.2 (GND), U6011.2 (GND), U6012.2 (GND), U6013.2 (NC), U6013.3 (GND), U6013.6 (SUB), U6013.7 (SUB), U6014.2 (NC), U6014.3 (GND), U6014.6 (SUB), U6014.7 (SUB), U6017.2 (GND), U6019.2 (GND), U6020.2 (NC), U6020.3 (GND), U6020.6 (SUB), U6020.7 (SUB), U6021.2 (NC), U6021.3 (GND), U6021.6 (SUB), U6021.7 (SUB), U6022.2 (NC), U6022.3 (GND), U6022.6 (SUB), U6022.7 (SUB); also elsewhere on the board
unnamed: C6009.2, C6011.1, R6022.1
unnamed: C6010.1, C6021.1, L6001.2, Q6001.1 (S), Q6001.2 (S)
unnamed: C6023.1, L6002.2, Q6002.1 (S), Q6002.2 (S)
unnamed: C6084.1, R6084.1
unnamed: F6001.2, L6002.1
unnamed: L6001.1, PS6001.2
unnamed: Q6001.4 (G), U6003.19 (OUT2-2)
unnamed: Q6001.3 (S), R6030.1
unnamed: Q6002.4 (G), U6003.27 (OUT2-1)
unnamed: Q6002.3 (S), R6029.2
unnamed: Q6003.3 (C), R6045.1, R6047.1
unnamed: C6041.1, Q6004.3 (G), R6045.2
unnamed: Q6006.6 (C1), R6060.1, R6063.1
unnamed: Q6006.3 (C2), R6061.1, R6064.1
unnamed: Q6007.3 (G), R6063.2
unnamed: Q6007.4 (S), R6060.2
unnamed: Q6008.3 (G), R6064.2
unnamed: Q6008.4 (S), R6061.2
unnamed: Q6009.6 (C1), R6079.1, R6081.1
unnamed: Q6009.3 (C2), R6083.1, R6085.1
unnamed: C6079.1, Q6010.2 (G1), R6081.2
unnamed: Q6010.1 (S1), R6079.2, TH6002.2
unnamed: C6085.1, Q6010.4 (G2), R6085.2
unnamed: Q6010.3 (S2), R6083.2, TH6001.2
unnamed: Q6012.3 (G), R6084.2, U6017.7 (G)
unnamed: R6019.1, R6020.2
unnamed: C6009.1, R6022.2, U6003.1 (-INE1)
unnamed: C6024.1, U6003.30 (CB1)
unnamed: C6025.2, U6003.16 (CB2)
unnamed: C6011.2, U6003.2 (FB1)
unnamed: C6036.1, R6033.1, U6003.25 (ILIM1)
unnamed: C6037.2, R6034.1, U6003.23 (ILIM2)
unnamed: R6029.1, U6003.29 (OUT1-1)
unnamed: R6030.2, U6003.17 (OUT1-2)
unnamed: R6031.2, U6003.21 (PWRGOOD)
unnamed: C6027.1, R6031.1, U6003.22 (VB)
unnamed: C6036.2, C6037.1, C6039.1, R6033.2, R6034.2, U6003.24 (VCC)
unnamed: C6024.2, L6003.1 (1_1), Q6002.8, Q6002.9, Q6002.10, Q6002.11, Q6002.12, Q6002.13, Q6002.14, U6003.28 (VS1)
unnamed: C6025.1, L6004.1, Q6001.8, Q6001.9, Q6001.10, Q6001.11, Q6001.12, Q6001.13, Q6001.14, U6003.18 (VS2)
unnamed: C6032.1, U6004.3 (Cd)
unnamed: C6055.1, U6008.4 (BP)
unnamed: C6056.1, FB6001.1, TP6048.1 (1_1), U6008.5 (OUT)
unnamed: C6076.2, U6017.1 (NACS)
unnamed: C6087.1, U6019.4 (BP)
unnamed: C6088.1, U6020.4 (Cn)
unnamed: C6004.1, U6023.3 (Cd)
unnamed: C6002.2, C6004.2, R6002.1, R6020.1, U6023.1 (GND)
unnamed: C6002.1, R6001.1, R6002.2, R6018.2, U6023.2 (VDD)
SW_1_A: C6090.1, U6020.5 (Cont); also elsewhere on the board
SW_1_B: U6013.5 (Cont); also elsewhere on the board
SW_4_B: Q6003.1 (B), Q6006.5 (B2), U6011.3 (Enable), U6014.5 (Cont); also elsewhere on the board
SW_6: U6012.3 (Enable); also elsewhere on the board
SW_8_B: C6096.1, U6007.3 (EN), U6017.3 (EN), U6019.3 (EN); also elsewhere on the board
SW_8_C: U6008.3 (EN); also elsewhere on the board
SW_ATA: C6500.1, Q6006.2 (B1), Q6009.2 (B1), Q6009.5 (B2); also elsewhere on the board
SW_PCI: U6021.5 (Cont), U6022.5 (Cont); also elsewhere on the board
~POW_FAIL: R6018.1, R6019.2, U6023.4 (OUT); also elsewhere on the board
~SYSCON_RST: R6032.1, U6004.4 (OUT), U6009.3 (EN); also elsewhere on the board
